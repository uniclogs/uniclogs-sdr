options:
  parameters:
    author: glennl
    comment: |-
      ~
      glennl
      jboone
    generate_options: qt_gui
    id: g3ruh_tx_rx
    output_language: python
    title: G3RUH Transmitter/Receiver
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: demod_input_rate
  id: variable
  parameters:
    value: symbol_rate * samples_per_symbol
  states: {}
- name: demod_sensitivity
  id: variable
  parameters:
    value: samples_per_symbol/(math.pi*modulation_index)
  states: {}
- name: deviation
  id: variable
  parameters:
    comment: |-
      Set for MSK,
      a subset of BFSK
    value: bit_rate/4
  states: {}
- name: f_offset
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-2000'
    step: '100'
    stop: '2000'
    value: '700'
  states: {}
- name: mod_input_rate
  id: variable
  parameters:
    value: symbol_rate /8
  states: {}
- name: mod_sensitivity
  id: variable
  parameters:
    value: (math.pi*modulation_index)/samples_per_symbol
  states: {}
- name: modulation_index
  id: variable
  parameters:
    value: deviation/(bit_rate/2)
  states: {}
- name: rf_frequency
  id: variable
  parameters:
    value: 436.5e6
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '5'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: Set for BFSK
    value: bit_rate
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Recovered packet
  states: {}
- name: blocks_message_debug_0_0_0_0
  id: blocks_message_debug
  parameters:
    comment: |-
      Send packet with
      invalid address
  states: {state: disabled}
- name: blocks_message_debug_0_0_0_0_0
  id: blocks_message_debug
  parameters:
    comment: |-
      Send packet with
      expected address
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Frequency translation providing
      "offset tuning" to move the DC bias
      artifact found in zero-IF receivers.
      - Jared Boone
    phase_inc: 2 * math.pi * -f_offset / samp_rate
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    comment: Received packet
    host: ''
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_CLIENT
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    comment: Packet to send
    host: ''
    mtu: '10000'
    port: '52002'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: |-
      Only use if no
      blocking hardware
      is in the loop
    samples_per_second: mod_input_rate
    type: byte
  states: {state: bypassed}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    comment: https://destevez.net/2016/05/scramblers-and-their-implementation-in-gnuradio/
    len: '16'
    mask: '0x0021'
    seed: '0x0000'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: samples_per_symbol
    sensitivity: demod_sensitivity
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: samples_per_symbol
    sensitivity: '0.33'
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    comment: https://destevez.net/2016/05/scramblers-and-their-implementation-in-gnuradio/
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: demod_input_rate
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    gain_dB_ch0: '40'
    oversample: '0'
    rf_freq: rf_frequency
    samp_rate: rf_samp_rate
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    gain_dB_ch0: '30'
    oversample: '0'
    rf_freq: rf_frequency
    samp_rate: rf_samp_rate
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Transmit at Modulator"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*10
    fc: '0'
    fftsize: '1024'
    name: '"Receive at Demodulator"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Transmit at SDR input"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*10
    fc: '0'
    fftsize: '1024'
    name: '"Transmit at Modulator"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Receive"'
    size: '1024'
    srate: symbol_rate
    type: float
    ymax: '1.2'
    ymin: '-0.2'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    fbw: '0.4'
    interp: demod_input_rate
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(rf_samp_rate/samp_rate)
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(rf_samp_rate/samp_rate)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2_0_0
  id: rational_resampler_xxx
  parameters:
    decim: symbol_rate * samples_per_symbol
    interp: samp_rate
    taps: ''
    type: ccc
  states: {}
- name: satellites_check_address_0
  id: satellites_check_address
  parameters:
    address: KJ7SU
    direction: '"from"'
  states: {}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '128'
  states: {}
- name: satellites_hdlc_framer_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '10'
    preamble_bytes: '50'
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: satellites_nrzi_encode_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', digital_scrambler_bb_0, '0']
- [blocks_rotator_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_socket_pdu_0_0, pdus, satellites_check_address_0, in]
- [blocks_socket_pdu_0_0, pdus, satellites_hdlc_framer_0, in]
- [blocks_throttle_0, '0', digital_gfsk_mod_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_throttle_0, '0']
- [digital_descrambler_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_descrambler_bb_0, '0', satellites_hdlc_deframer_0, '0']
- [digital_gfsk_demod_0, '0', satellites_nrzi_decode_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_const_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_1_0_0, '0']
- [digital_gfsk_mod_0, '0', rational_resampler_xxx_2_0_0, '0']
- [digital_scrambler_bb_0, '0', satellites_nrzi_encode_0, '0']
- [limesdr_source_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', digital_gfsk_demod_0, '0']
- [rational_resampler_xxx_0, '0', fosphor_qt_sink_c_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', satellites_rms_agc_0, '0']
- [rational_resampler_xxx_2_0, '0', limesdr_sink_0, '0']
- [rational_resampler_xxx_2_0, '0', qtgui_freq_sink_x_1_0, '0']
- [rational_resampler_xxx_2_0_0, '0', rational_resampler_xxx_2_0, '0']
- [satellites_check_address_0, fail, blocks_message_debug_0_0_0_0, print_pdu]
- [satellites_check_address_0, ok, blocks_message_debug_0_0_0_0_0, print_pdu]
- [satellites_hdlc_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_hdlc_deframer_0, out, blocks_socket_pdu_0, pdus]
- [satellites_hdlc_framer_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_nrzi_decode_0, '0', digital_descrambler_bb_0, '0']
- [satellites_nrzi_encode_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [satellites_rms_agc_0, '0', blocks_rotator_cc_0, '0']

metadata:
  file_format: 1
