options:
  parameters:
    author: glennl
    comment: |-
      ~
      See:
      https://github.com/oresat/uniclogs-sdr/flowgraphs
    generate_options: qt_gui
    id: OreSat0_v1_1_1
    output_language: python
    title: UHF G3RUH & EDL Receiver / UHF -or- L-Band EDL Transmitter
  states: {}

blocks:
- name: L_mod_input_rate
  id: variable
  parameters:
    value: L_tx_symbol_rate /8
  states: {}
- name: L_mod_sensitivity
  id: variable
  parameters:
    value: (math.pi*L_tx_modulation_index)/L_tx_samples_per_symbol
  states: {}
- name: L_tx_bit_rate
  id: variable
  parameters:
    value: '60000'
  states: {}
- name: L_tx_deviation
  id: variable
  parameters:
    comment: |-
      Set for MSK,
      a subset of BFSK
    value: L_tx_bit_rate/3
  states: {}
- name: L_tx_lna_gain
  id: variable
  parameters:
    comment: Unused
    value: '1'
  states: {state: disabled}
- name: L_tx_modulation_index
  id: variable
  parameters:
    value: L_tx_deviation/(L_tx_bit_rate/2)
  states: {}
- name: L_tx_pa_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '50'
  states: {state: disabled}
- name: L_tx_pa_gain
  id: variable
  parameters:
    comment: |-
      Use for headless version;
      Set value used with previous
      setting of QT GUI Range
    value: '20'
  states: {state: disabled}
- name: L_tx_ptt_switch
  id: variable_qtgui_chooser
  parameters:
    label0: 'Off'
    label1: On (Transmit)
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '1'
    widget: radio_buttons
  states: {state: disabled}
- name: L_tx_rf_frequency
  id: variable
  parameters:
    value: 1265e6
  states: {state: disabled}
- name: L_tx_samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: L_tx_samples_per_symbol
  id: variable
  parameters:
    value: '4'
  states: {}
- name: L_tx_symbol_rate
  id: variable
  parameters:
    comment: Set for BFSK
    value: L_tx_bit_rate
  states: {}
- name: bit_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: bit_rate_0
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: demod_input_rate
  id: variable
  parameters:
    value: symbol_rate * samples_per_symbol
  states: {}
- name: demod_input_rate_0
  id: variable
  parameters:
    value: symbol_rate_0 * samples_per_symbol_0
  states: {}
- name: demod_sensitivity
  id: variable
  parameters:
    value: samples_per_symbol/(math.pi*modulation_index)
  states: {}
- name: demod_sensitivity_0
  id: variable
  parameters:
    value: samples_per_symbol_0/(math.pi*modulation_index_0)
  states: {}
- name: deviation
  id: variable
  parameters:
    comment: |-
      Set for MSK,
      a subset of BFSK
    value: bit_rate/4
  states: {}
- name: deviation_0
  id: variable
  parameters:
    comment: |-
      Set for MSK,
      a subset of BFSK
    value: bit_rate_0/4
  states: {}
- name: f_offset
  id: variable
  parameters:
    comment: |-
      Pick out our RF
      carrier in the Rx
      bandwidth
    value: 1.5e6
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: lna_gain
  id: variable
  parameters:
    comment: |-
      Use for headless version;
      Set value used with previous
      setting of QT GUI Range
    value: '20'
  states: {state: disabled}
- name: mod_input_rate
  id: variable
  parameters:
    value: tx_symbol_rate /8
  states: {}
- name: mod_sensitivity
  id: variable
  parameters:
    value: (math.pi*tx_modulation_index)/tx_samples_per_symbol
  states: {}
- name: modulation_index
  id: variable
  parameters:
    value: deviation/(bit_rate/2)
  states: {}
- name: modulation_index_0
  id: variable
  parameters:
    value: deviation_0/(bit_rate_0/2)
  states: {}
- name: pa_gain
  id: variable
  parameters:
    comment: Unused
    value: '1'
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: rx_doppler_offset
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-13000'
    step: '1'
    stop: '13000'
    value: '0'
  states: {state: disabled}
- name: rx_mute
  id: variable_qtgui_check_box
  parameters:
    'false': 'True'
    'true': 'False'
    type: real
    value: 'True'
  states: {}
- name: rx_rf_frequency
  id: variable
  parameters:
    value: 435e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samples_per_symbol_0
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: Set for BFSK
    value: bit_rate
  states: {}
- name: symbol_rate_0
  id: variable
  parameters:
    comment: Set for BFSK
    value: bit_rate_0
  states: {}
- name: tx_bit_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: tx_deviation
  id: variable
  parameters:
    comment: |-
      Set for MSK,
      a subset of BFSK
    value: tx_bit_rate/4
  states: {}
- name: tx_doppler_offset
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-100000'
    step: '1'
    stop: '100000'
    value: '0'
  states: {state: disabled}
- name: tx_doppler_offset
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-100000'
    step: '1'
    stop: '100000'
    value: '0'
  states: {state: disabled}
- name: tx_lna_gain
  id: variable
  parameters:
    comment: Unused
    value: '1'
  states: {}
- name: tx_modulation_index
  id: variable
  parameters:
    value: tx_deviation/(tx_bit_rate/2)
  states: {}
- name: tx_pa_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '37'
  states: {}
- name: tx_pa_gain
  id: variable
  parameters:
    comment: |-
      Use for headless version;
      Set value used with previous
      setting of QT GUI Range
    value: '20'
  states: {state: disabled}
- name: tx_ptt_switch
  id: variable_qtgui_chooser
  parameters:
    label0: 'Off'
    label1: On (Transmit)
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: tx_rf_frequency
  id: variable
  parameters:
    value: 436.5e6+8e3
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: tx_samples_per_symbol
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_symbol_rate
  id: variable
  parameters:
    comment: Set for BFSK
    value: tx_bit_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: rf_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: rx_mute
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: rf_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: rf_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: rf_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /media/glennl/My Passport/sdr_data/OreSat0.raw
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /media/glennl/My Passport/sdr_data/OreSat0_doppler.raw
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Recovered APRS
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    comment: Recovered EDL
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters:
    comment: Recovered EDL
  states: {state: disabled}
- name: blocks_message_debug_0_0_0_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0_0_0_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0_0_0_0_0_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0_0_0_0_0_1_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0_0_0_0_0_1_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters:
    comment: Recovered APRS
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1_1_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '100'
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0_1_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_1
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_1_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_1_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_1_1_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '2000'
    minsize: '2000'
  states: {state: disabled}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2 * math.pi * (-f_offset) / rf_samp_rate
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    comment: Received APRS beacon
    host: 127.0.0.1
    mtu: '10000'
    port: '10015'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {state: disabled}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    comment: EDL to send
    host: 10.10.2.4
    mtu: '10000'
    port: '10025'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_0_0_0_0
  id: blocks_socket_pdu
  parameters:
    comment: EDL to send
    host: 10.10.2.4
    mtu: '10000'
    port: '10025'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {state: disabled}
- name: blocks_socket_pdu_0_1
  id: blocks_socket_pdu
  parameters:
    comment: Received EDL
    host: localhost
    mtu: '10000'
    port: '10016'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: blocks_socket_pdu_0_1_0
  id: blocks_socket_pdu
  parameters:
    comment: Received EDL
    host: 10.10.1.5
    mtu: '10000'
    port: '10016'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {state: disabled}
- name: blocks_socket_pdu_0_2
  id: blocks_socket_pdu
  parameters:
    comment: Received APRS beacon
    host: localhost
    mtu: '10000'
    port: '10015'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_to_pdu_0_1_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_1_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_1_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_1_1_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {state: disabled}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    comment: https://destevez.net/2016/05/scramblers-and-their-implementation-in-gnuradio/
    len: '16'
    mask: '0x0021'
    seed: '0x0000'
  states: {state: disabled}
- name: digital_descrambler_bb_0_0
  id: digital_descrambler_bb
  parameters:
    comment: https://destevez.net/2016/05/scramblers-and-their-implementation-in-gnuradio/
    len: '16'
    mask: '0x0021'
    seed: '0x0000'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: samples_per_symbol
    sensitivity: demod_sensitivity
  states: {state: disabled}
- name: digital_gfsk_demod_0_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: samples_per_symbol_0
    sensitivity: demod_sensitivity_0
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: tx_samples_per_symbol
    sensitivity: mod_sensitivity
  states: {}
- name: digital_gfsk_mod_0_0_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: L_tx_samples_per_symbol
    sensitivity: L_mod_sensitivity
  states: {state: disabled}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    comment: https://destevez.net/2016/05/scramblers-and-their-implementation-in-gnuradio/
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: digital_scrambler_bb_0_0_0
  id: digital_scrambler_bb
  parameters:
    comment: https://destevez.net/2016/05/scramblers-and-their-implementation-in-gnuradio/
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nfreeqin = 0\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, downlink=0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='GPredict Doppler reducer',   # will show up in GRC\n            in_sig=None,\n            out_sig=None\n        )\n        self.downlink = downlink\n        self.message_port_register_in(pmt.intern('gpredict_freq'))\n        self.message_port_register_out(pmt.intern('freq'))\n        self.set_msg_handler(pmt.intern('gpredict_freq'), self.handle_msg)\n\n    def handle_msg(self, msg):\n        global freeqin\n        if pmt.is_pair(msg):\n            freeqin = pmt.to_python(pmt.cdr(msg)) - self.downlink\n            #self.message_port_pub(pmt.intern('freq'),pmt.from_double(freeqin))\n            #self.message_port_pub(pmt.intern('freq'),pmt.cons(pmt.intern('freq'),pmt.from_double(freeqin)))\n            self.message_port_pub(pmt.intern('freq'),pmt.dict_add(pmt.make_dict(), pmt.intern(\"freq\"), pmt.from_double(freeqin)))\n            #print('published: \"%i\"'%freeqin)\n\n"
    downlink: rx_rf_frequency+f_offset
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nfreeqin = 0\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, downlink=0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='GPredict Doppler reducer',   # will show up in GRC\n            in_sig=None,\n            out_sig=None\n        )\n        self.downlink = downlink\n        self.message_port_register_in(pmt.intern('gpredict_freq'))\n        self.message_port_register_out(pmt.intern('freq'))\n        self.set_msg_handler(pmt.intern('gpredict_freq'), self.handle_msg)\n\n    def handle_msg(self, msg):\n        global freeqin\n        if pmt.is_pair(msg):\n            freeqin = pmt.to_python(pmt.cdr(msg)) - self.downlink\n            #self.message_port_pub(pmt.intern('freq'),pmt.from_double(freeqin))\n            #self.message_port_pub(pmt.intern('freq'),pmt.cons(pmt.intern('freq'),pmt.from_double(freeqin)))\n            self.message_port_pub(pmt.intern('freq'),pmt.dict_add(pmt.make_dict(), pmt.intern(\"freq\"), pmt.from_double(freeqin)))\n            #print('published: \"%i\"'%freeqin)\n\n"
    downlink: L_tx_rf_frequency
  states: {state: disabled}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nfreeqin = 0\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, downlink=0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='GPredict Doppler reducer',   # will show up in GRC\n            in_sig=None,\n            out_sig=None\n        )\n        self.downlink = downlink\n        self.message_port_register_in(pmt.intern('gpredict_freq'))\n        self.message_port_register_out(pmt.intern('freq'))\n        self.set_msg_handler(pmt.intern('gpredict_freq'), self.handle_msg)\n\n    def handle_msg(self, msg):\n        global freeqin\n        if pmt.is_pair(msg):\n            freeqin = pmt.to_python(pmt.cdr(msg)) - self.downlink\n            #self.message_port_pub(pmt.intern('freq'),pmt.from_double(freeqin))\n            #self.message_port_pub(pmt.intern('freq'),pmt.cons(pmt.intern('freq'),pmt.from_double(freeqin)))\n            self.message_port_pub(pmt.intern('freq'),pmt.dict_add(pmt.make_dict(), pmt.intern(\"freq\"), pmt.from_double(freeqin)))\n            #print('published: \"%i\"'%freeqin)\n\n"
    downlink: tx_rf_frequency-8e3
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: '7356'
    verbose: 'False'
  states: {}
- name: gpredict_doppler_0_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: '7358'
    verbose: 'False'
  states: {state: disabled}
- name: gpredict_doppler_0_0_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: '7358'
    verbose: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    digital_bandw_ch0: rf_samp_rate
    digital_bandw_ch1: rf_samp_rate
    gain_dB_ch0: tx_pa_gain*tx_ptt_switch
    oversample: '0'
    pa_path_ch0: '1'
    rf_freq: tx_rf_frequency
    samp_rate: rf_samp_rate
  states: {}
- name: limesdr_sink_0_0_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    digital_bandw_ch0: rf_samp_rate
    digital_bandw_ch1: rf_samp_rate
    gain_dB_ch0: L_tx_pa_gain*L_tx_ptt_switch
    oversample: '0'
    pa_path_ch0: '2'
    rf_freq: L_tx_rf_frequency
    samp_rate: rf_samp_rate
  states: {state: disabled}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    digital_bandw_ch0: rf_samp_rate
    digital_bandw_ch1: rf_samp_rate
    gain_dB_ch0: lna_gain
    gain_dB_ch1: lna_gain
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: rx_rf_frequency
    samp_rate: rf_samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate*0.4
    decim: int(rf_samp_rate/samp_rate)
    gain: '1'
    samp_rate: rf_samp_rate
    type: fir_filter_ccf
    width: samp_rate*0.2
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate_0*0.4
    decim: int(rf_samp_rate/samp_rate_0)
    gain: '1'
    samp_rate: rf_samp_rate
    type: fir_filter_ccf
    width: samp_rate_0*0.2
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Set for 9600 b/s
      G3RUH Modulation
      AX.25 Frames
    note: APRS Receiver variables
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      Set for 96k b/s
      MSK Modulatgion
      EDL / CCSDS Frames
    note: EDL Receiver variables
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    comment: |-
      UHF Transmitter
      Set for 96k b/s
      MSK Modulatgion
      EDL / CCSDS Frames
    note: UHF Transmitter
  states: {}
- name: note_0_0_0_0_0
  id: note
  parameters:
    comment: |-
      L-Band transmitter
      Set for 60 or 120k b/s
      MSK Modulatgion
      EDL / CCSDS Frames
    note: L-Band Transmitter
  states: {}
- name: note_0_1
  id: note
  parameters:
    comment: |-
      UHF Receiver
      435 to 438 MHz Amateur Band

      UHF Transmitter
      435 to 438 MHz Amateur Band

      L-Band Transmitter
      1260 to 1270 MHz Amateur Band
    note: SDR Setup
  states: {}
- name: note_1
  id: note
  parameters:
    note: UHF Receiver
  states: {}
- name: note_2
  id: note
  parameters:
    note: UHF Transmitter
  states: {}
- name: note_3
  id: note
  parameters:
    note: L-Band Transmitter
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"APRS Receive into Demodulator"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_0
    fc: '0'
    fftsize: '1024'
    name: '"EDL Receive into Demodulator"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: rf_samp_rate
    fc: rx_rf_frequency
    fftsize: '1024'
    name: '"Translated RF"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rf_samp_rate
    fc: tx_rf_frequency
    fftsize: '1024'
    name: '"UHF Transmit spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rf_samp_rate
    fc: L_tx_rf_frequency
    fftsize: '1024'
    name: '"L Transmit spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_1
  id: qtgui_freq_sink_x
  parameters:
    bw: rf_samp_rate
    fc: rx_rf_frequency
    fftsize: '1024'
    grid: 'True'
    name: '"Received RF"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Rx Doppler"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: demod_input_rate
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate_0
    interp: demod_input_rate_0
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(rf_samp_rate/tx_samp_rate)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2_0_0
  id: rational_resampler_xxx
  parameters:
    decim: tx_symbol_rate * tx_samples_per_symbol
    interp: tx_samp_rate
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: L_tx_symbol_rate * L_tx_samples_per_symbol
    interp: L_tx_samp_rate
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_2_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(rf_samp_rate/L_tx_samp_rate)
    taps: ''
    type: ccc
  states: {state: disabled}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {}
- name: satellites_ax25_deframer_0_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {state: disabled}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: symbol_rate
    iq: 'True'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: satellites_fsk_demodulator_0_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: symbol_rate_0
    iq: 'True'
    samp_rate: samp_rate_0
    subaudio: 'False'
  states: {state: disabled}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '300'
  states: {state: disabled}
- name: satellites_hdlc_deframer_0_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '300'
  states: {}
- name: satellites_hdlc_framer_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '10'
    preamble_bytes: '50'
  states: {}
- name: satellites_hdlc_framer_0_0_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '10'
    preamble_bytes: '50'
  states: {state: disabled}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {state: disabled}
- name: satellites_nrzi_decode_0_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: satellites_nrzi_encode_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: satellites_nrzi_encode_0_0_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_2, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_1, '0']
- [analog_sig_source_x_0_1_0, '0', blocks_multiply_xx_0_1_0, '0']
- [blocks_message_strobe_0, strobe, blocks_random_pdu_0, generate]
- [blocks_multiply_xx_0, '0', blocks_file_sink_1, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_xx_0_0, '0', blocks_rotator_cc_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_freq_sink_x_1_1, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_xx_0_1, '0', limesdr_sink_0_0_0, '0']
- [blocks_multiply_xx_0_1, '0', qtgui_freq_sink_x_1_0_0_0, '0']
- [blocks_multiply_xx_0_1_0, '0', limesdr_sink_0, '0']
- [blocks_multiply_xx_0_1_0, '0', qtgui_freq_sink_x_1_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_unpacked_to_packed_xx_1, '0']
- [blocks_packed_to_unpacked_xx_0_0, '0', blocks_unpacked_to_packed_xx_1_0, '0']
- [blocks_packed_to_unpacked_xx_0_0_0, '0', blocks_unpacked_to_packed_xx_1_0_0, '0']
- [blocks_packed_to_unpacked_xx_0_1_0, '0', blocks_unpacked_to_packed_xx_1_1_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', digital_scrambler_bb_0, '0']
- [blocks_pdu_to_tagged_stream_0_0_0, '0', digital_scrambler_bb_0_0_0, '0']
- [blocks_pdu_to_tagged_stream_1, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_pdu_to_tagged_stream_1_0, '0', blocks_packed_to_unpacked_xx_0_0, '0']
- [blocks_pdu_to_tagged_stream_1_0_0, '0', blocks_packed_to_unpacked_xx_0_0_0, '0']
- [blocks_pdu_to_tagged_stream_1_1_0, '0', blocks_packed_to_unpacked_xx_0_1_0, '0']
- [blocks_random_pdu_0, pdus, blocks_message_debug_0_0_0_0_0_0_1_0_0, print_pdu]
- [blocks_rotator_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_socket_pdu_0_0, pdus, blocks_message_debug_0_0_0_0_0_0, print_pdu]
- [blocks_socket_pdu_0_0, pdus, blocks_pdu_to_tagged_stream_1, pdus]
- [blocks_socket_pdu_0_0_0_0, pdus, blocks_message_debug_0_0_0_0_0_0_1_0, print_pdu]
- [blocks_socket_pdu_0_0_0_0, pdus, blocks_pdu_to_tagged_stream_1_1_0, pdus]
- [blocks_tagged_stream_to_pdu_0, pdus, satellites_hdlc_framer_0, in]
- [blocks_tagged_stream_to_pdu_0_0, pdus, blocks_message_debug_0_0, print_pdu]
- [blocks_tagged_stream_to_pdu_0_0, pdus, blocks_socket_pdu_0_1, pdus]
- [blocks_tagged_stream_to_pdu_0_0_0, pdus, blocks_message_debug_0_0_0, print_pdu]
- [blocks_tagged_stream_to_pdu_0_0_0, pdus, blocks_socket_pdu_0_1_0, pdus]
- [blocks_tagged_stream_to_pdu_0_1_0, pdus, satellites_hdlc_framer_0_0_0, in]
- [blocks_unpacked_to_packed_xx_0, '0', digital_gfsk_mod_0, '0']
- [blocks_unpacked_to_packed_xx_0_0_0, '0', digital_gfsk_mod_0_0_0, '0']
- [blocks_unpacked_to_packed_xx_1, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_unpacked_to_packed_xx_1_0, '0', blocks_tagged_stream_to_pdu_0_0, '0']
- [blocks_unpacked_to_packed_xx_1_0_0, '0', blocks_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_unpacked_to_packed_xx_1_1_0, '0', blocks_tagged_stream_to_pdu_0_1_0, '0']
- [digital_descrambler_bb_0, '0', satellites_hdlc_deframer_0, '0']
- [digital_descrambler_bb_0_0, '0', satellites_hdlc_deframer_0_0, '0']
- [digital_gfsk_demod_0, '0', satellites_nrzi_decode_0, '0']
- [digital_gfsk_demod_0_0, '0', satellites_nrzi_decode_0_0, '0']
- [digital_gfsk_mod_0, '0', rational_resampler_xxx_2_0_0, '0']
- [digital_gfsk_mod_0_0_0, '0', rational_resampler_xxx_2_0_0_0_0, '0']
- [digital_scrambler_bb_0, '0', satellites_nrzi_encode_0, '0']
- [digital_scrambler_bb_0_0_0, '0', satellites_nrzi_encode_0_0_0, '0']
- [epy_block_0, freq, analog_sig_source_x_0, cmd]
- [epy_block_0, freq, blocks_message_debug_1, print]
- [epy_block_0_0, freq, analog_sig_source_x_0_1, cmd]
- [epy_block_0_0, freq, blocks_message_debug_1_0, print]
- [epy_block_0_0_0, freq, analog_sig_source_x_0_1_0, cmd]
- [epy_block_0_0_0, freq, blocks_message_debug_1_0_0, print]
- [gpredict_doppler_0, freq, epy_block_0, gpredict_freq]
- [gpredict_doppler_0, state, blocks_message_debug_1_1, print]
- [gpredict_doppler_0_0, freq, epy_block_0_0, gpredict_freq]
- [gpredict_doppler_0_0, state, blocks_message_debug_1_1_0, print]
- [gpredict_doppler_0_0_0, freq, epy_block_0_0_0, gpredict_freq]
- [limesdr_source_0, '0', blocks_file_sink_0, '0']
- [limesdr_source_0, '0', blocks_multiply_xx_0_0, '1']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', satellites_fsk_demodulator_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0_0, '0', satellites_fsk_demodulator_0_0, '0']
- [rational_resampler_xxx_0, '0', digital_gfsk_demod_0, '0']
- [rational_resampler_xxx_0_0, '0', digital_gfsk_demod_0_0, '0']
- [rational_resampler_xxx_2_0, '0', blocks_multiply_xx_0_1_0, '1']
- [rational_resampler_xxx_2_0_0, '0', rational_resampler_xxx_2_0, '0']
- [rational_resampler_xxx_2_0_0_0_0, '0', rational_resampler_xxx_2_0_1_0, '0']
- [rational_resampler_xxx_2_0_1_0, '0', blocks_multiply_xx_0_1, '1']
- [satellites_ax25_deframer_0, out, blocks_message_debug_0_1, print_pdu]
- [satellites_ax25_deframer_0, out, blocks_socket_pdu_0_2, pdus]
- [satellites_ax25_deframer_0_0, out, blocks_pdu_to_tagged_stream_1_0_0, pdus]
- [satellites_fsk_demodulator_0, '0', satellites_ax25_deframer_0, '0']
- [satellites_fsk_demodulator_0_0, '0', satellites_ax25_deframer_0_0, '0']
- [satellites_hdlc_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_hdlc_deframer_0, out, blocks_socket_pdu_0, pdus]
- [satellites_hdlc_deframer_0_0, out, blocks_pdu_to_tagged_stream_1_0, pdus]
- [satellites_hdlc_framer_0, out, blocks_message_debug_0_0_0_0_0_0_0, print_pdu]
- [satellites_hdlc_framer_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_hdlc_framer_0_0_0, out, blocks_message_debug_0_0_0_0_0_0_0_0_0, print_pdu]
- [satellites_hdlc_framer_0_0_0, out, blocks_pdu_to_tagged_stream_0_0_0, pdus]
- [satellites_nrzi_decode_0, '0', digital_descrambler_bb_0, '0']
- [satellites_nrzi_decode_0_0, '0', digital_descrambler_bb_0_0, '0']
- [satellites_nrzi_encode_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [satellites_nrzi_encode_0_0_0, '0', blocks_unpacked_to_packed_xx_0_0_0, '0']

metadata:
  file_format: 1
