options:
  parameters:
    author: GlennL & KennyM
    comment: |-
      ~
      See:
      https://github.com/oresat/uniclogs-sdr/flowgraphs
    generate_options: no_gui
    id: OreSat0
    output_language: python
    run_options: run
    title: UHF G3RUH & EDL Receiver / UHF -or- L-Band EDL Transmitter
  states: {}

blocks:
- name: EDL_strobe_command
  id: variable_config
  parameters:
    config_file: conf
    option: edl_command_number
    section: edl_commands
    type: string
    value: c4f53800003100000100000001e500017a7715fd13ff27df16880dbe3aca6e7ce2e1fa00a28426945342e12e6f4614ca
    writeback: None
  states: {}
- name: aos_mute
  id: variable
  parameters:
    comment: |-
      Start up with mute 1=off
      Maybe this should change for production
    value: '1'
  states: {}
- name: f_offset
  id: variable
  parameters:
    comment: |-
      Pick out our RF
      carrier in the Rx
      bandwidth
    value: rf_samp_rate/4
  states: {}
- name: gpredict_rx_frequency
  id: variable
  parameters:
    value: rx_target_frequency
  states: {}
- name: gpredict_tx_frequency
  id: variable
  parameters:
    value: tx_center_frequency
  states: {}
- name: morse_bump
  id: variable
  parameters:
    value: '0'
  states: {}
- name: morse_callsign
  id: variable_config
  parameters:
    config_file: conf
    option: morse_callsign
    section: main
    type: string
    value: KJ7SAT
    writeback: None
  states: {}
- name: rf_samp_rate
  id: variable_config
  parameters:
    config_file: conf
    option: rf_samp_rate
    section: main
    type: real
    value: 1.92e6
    writeback: None
  states: {}
- name: rx_beacon_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: rx_beacon
    type: int
    value: '9600'
    writeback: None
  states: {}
- name: rx_edl_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: rx_edl
    type: int
    value: '96000'
    writeback: None
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '73'
    value: '35'
  states: {state: disabled}
- name: rx_target_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: target_frequency
    section: rx
    type: real
    value: 436.5e6
    writeback: None
  states: {}
- name: rx_tune_frequency
  id: variable
  parameters:
    value: rx_target_frequency - f_offset
  states: {}
- name: samples_per_symbol
  id: variable_config
  parameters:
    config_file: conf
    option: samples_per_symbol
    section: main
    type: int
    value: '4'
    writeback: None
  states: {}
- name: telemetry_host
  id: variable_config
  parameters:
    config_file: conf
    option: telemetry_host
    section: main
    type: string
    value: localhost
    writeback: None
  states: {}
- name: tx_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: txband
    type: int
    value: '60000'
    writeback: None
  states: {}
- name: tx_center_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: center_frequency
    section: txband
    type: real
    value: 1265e6
    writeback: None
  states: {}
- name: tx_channel
  id: variable_config
  parameters:
    config_file: conf
    option: channel
    section: txband
    type: int
    value: '0'
    writeback: None
  states: {}
- name: tx_deviation
  id: variable_config
  parameters:
    config_file: conf
    option: deviation
    section: txband
    type: int
    value: '20000'
    writeback: None
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '6'
    step: '1'
    stop: '73'
    value: '50'
  states: {state: disabled}
- name: tx_hackrf_serial
  id: variable_config
  parameters:
    config_file: conf
    option: hackrf_serial
    section: txband
    type: string
    value: '0'
    writeback: None
  states: {}
- name: tx_occupied_bandwidth
  id: variable
  parameters:
    value: tx_bit_rate+2*tx_deviation
  states: {}
- name: tx_offset
  id: variable
  parameters:
    value: 2 * tx_occupied_bandwidth
  states: {}
- name: tx_path
  id: variable_config
  parameters:
    config_file: conf
    option: path
    section: txband
    type: int
    value: '2'
    writeback: None
  states: {}
- name: tx_ptt_switch
  id: variable
  parameters:
    comment: |-
      This is a gain shunt
      only used by the Lime
    value: '1'
  states: {}
- name: tx_ptt_switch
  id: variable_qtgui_chooser
  parameters:
    label0: 'Off'
    label1: On (Transmit)
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '1'
    widget: radio_buttons
  states: {state: disabled}
- name: tx_selector_options
  id: variable
  parameters:
    value: '[''cw'', ''edl'', ''morse'']'
  states: {}
- name: tx_tune_frequency
  id: variable
  parameters:
    value: tx_center_frequency - tx_offset
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Combine the offset tuning and doppler adjustments here
    freq: rx_tune_frequency - gpredict_rx_frequency
    offset: '0'
    phase: '0'
    samp_rate: rf_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: gpredict_tx_frequency - tx_center_frequency + tx_offset
    offset: '0'
    phase: '0'
    samp_rate: rf_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: rf_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: OreSat0.cf32
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: EDL_command.cf32
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: OreSat0.cf32
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Recovered APRS
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    comment: Recovered EDL
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters:
    comment: Recovered EDL
  states: {state: disabled}
- name: blocks_message_debug_0_0_0_0_0_0_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0_0_0_0_0_1_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters:
    comment: Recovered APRS
  states: {state: disabled}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(bytes.fromhex(EDL_strobe_command)), list(bytes.fromhex(EDL_strobe_command))))
    period: strobe_delay
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: gpredict_tx_frequency
  states: {}
- name: blocks_msgpair_to_var_1
  id: blocks_msgpair_to_var
  parameters:
    target: aos_mute
  states: {}
- name: blocks_msgpair_to_var_2
  id: blocks_msgpair_to_var
  parameters:
    target: gpredict_rx_frequency
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: multiply_constant
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: not bool(aos_mute)
    type: complex
  states: {}
- name: blocks_mute_xx_1
  id: blocks_mute_xx
  parameters:
    mute: not bool(aos_mute)
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0_1_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: tx_selector_options.index(tx_selector)
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: samples_per_symbol
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_0_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_1_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_1_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_1_1_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: msg
    target: morse_bump
  states: {}
- name: conf
  id: parameter
  parameters:
    label: config file
    short_id: c
    type: str
    value: OreSat0.cfg
  states: {}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'True'
    length_tag_name: packet_len
    post_padding: 16*1024
    pre_padding: 16*1024
    type: complex
    window: firdes.window(window.WIN_HANN, 50, 0)
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '0111111001111110'
    type: byte
  states: {state: disabled}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    comment: https://destevez.net/2016/05/scramblers-and-their-implementation-in-gnuradio/
    len: '16'
    mask: '0x0021'
    seed: '0x0000'
  states: {}
- name: digital_descrambler_bb_0_0
  id: digital_descrambler_bb
  parameters:
    comment: https://destevez.net/2016/05/scramblers-and-their-implementation-in-gnuradio/
    len: '16'
    mask: '0x0021'
    seed: '0x0000'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: samples_per_symbol
    sensitivity: 2*samples_per_symbol/math.pi
  states: {}
- name: digital_gfsk_demod_0_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: samples_per_symbol
    sensitivity: 2*samples_per_symbol/math.pi
  states: {}
- name: digital_gfsk_demod_0_1
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: samples_per_symbol
    sensitivity: math.pi*rx_beacon_bit_rate*1.5/samples_per_symbol
  states: {state: disabled}
- name: digital_gfsk_mod_0_0_0
  id: digital_gfsk_mod
  parameters:
    bt: tx_bt
    samples_per_symbol: samples_per_symbol
    sensitivity: math.pi*(2*tx_deviation/tx_bit_rate)/samples_per_symbol
  states: {}
- name: digital_scrambler_bb_0_0_0
  id: digital_scrambler_bb
  parameters:
    comment: https://destevez.net/2016/05/scramblers-and-their-implementation-in-gnuradio/
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: edl_command_number
  id: parameter
  parameters:
    label: the command number, found in the edl_commands section of the config file, for repeat attempts of sending the same command
    short_id: e
    type: str
    value: default
  states: {}
- name: fix_relative_paths
  id: epy_module
  parameters:
    source_code: |
      import os

      script_path = os.path.dirname(os.path.realpath(__file__))
      os.chdir(script_path)
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 0.0.0.0
    gpredict_port: '7356'
    verbose: 'False'
  states: {}
- name: gpredict_doppler_0_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 0.0.0.0
    gpredict_port: '7358'
    verbose: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: limesdr_sink_0_0_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: tx_channel
    digital_bandw_ch0: rf_samp_rate
    digital_bandw_ch1: rf_samp_rate
    gain_dB_ch0: tx_gain*tx_ptt_switch
    gain_dB_ch1: tx_gain*tx_ptt_switch
    oversample: '0'
    pa_path_ch0: tx_path
    pa_path_ch1: tx_path
    rf_freq: tx_tune_frequency
    samp_rate: rf_samp_rate
  states: {state: disabled}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: tx_channel
    digital_bandw_ch0: rf_samp_rate
    digital_bandw_ch1: rf_samp_rate
    gain_dB_ch0: rx_gain
    gain_dB_ch1: rx_gain
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: rx_tune_frequency
    samp_rate: rf_samp_rate
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: rx_beacon_bit_rate*1.5
    decim: '1'
    gain: '1'
    samp_rate: rf_samp_rate
    type: fir_filter_ccf
    width: rx_beacon_bit_rate*0.75
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: rx_edl_bit_rate*1.5
    decim: '1'
    gain: '1'
    samp_rate: rf_samp_rate
    type: fir_filter_ccf
    width: rx_edl_bit_rate*0.75
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: tx_occupied_bandwidth * 1.2
    decim: '1'
    gain: '1'
    samp_rate: rf_samp_rate
    type: fir_filter_ccf
    width: tx_bit_rate
    win: window.WIN_HAMMING
  states: {}
- name: morse_hier_0
  id: morse_hier
  parameters:
    morse_dpw: '50'
    morse_wpm: '20'
    rf_samp_rate: rf_samp_rate
    verbose: 'True'
  states: {}
- name: multiply_constant
  id: parameter
  parameters:
    comment: This is experimental
    label: TX signal reducer
    short_id: m
    type: eng_float
    value: '.6'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    comment: Received APRS beacon
    host: telemetry_host
    mtu: '10000'
    port: '10015'
    type: UDP_CLIENT
  states: {}
- name: network_socket_pdu_0_0_0_0
  id: network_socket_pdu
  parameters:
    comment: EDL to send
    host: 0.0.0.0
    mtu: '10000'
    port: '10025'
    type: UDP_SERVER
  states: {}
- name: network_socket_pdu_0_1
  id: network_socket_pdu
  parameters:
    comment: Received EDL response
    host: telemetry_host
    mtu: '10000'
    port: '10016'
    type: UDP_CLIENT
  states: {}
- name: network_socket_pdu_0_1_0
  id: network_socket_pdu
  parameters:
    comment: Received EDL
    host: localhost
    mtu: '10000'
    port: '10016'
    type: UDP_CLIENT
  states: {state: disabled}
- name: network_socket_pdu_0_2
  id: network_socket_pdu
  parameters:
    comment: Received APRS beacon
    host: localhost
    mtu: '10000'
    port: '10015'
    type: UDP_CLIENT
  states: {state: disabled}
- name: noise
  id: parameter
  parameters:
    comment: |-
      Only useful during development
      Leave at 0 for amplified transmission!
    label: amplitude of noise to be added
    short_id: n
    type: eng_float
    value: '0'
  states: {}
- name: note_0
  id: note
  parameters:
    note: TX magic below this point
  states: {}
- name: note_1
  id: note
  parameters:
    note: Config file variables below this point
  states: {}
- name: note_2
  id: note
  parameters:
    note: RX magic below this point
  states: {}
- name: note_4
  id: note
  parameters:
    note: RX magic happens here
  states: {}
- name: note_5
  id: note
  parameters:
    note: TX magic happens here
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf="+tx_hackrf_serial'
    bb_gain0: '0'
    comment: tx gain can be 0-47
    freq0: tx_tune_frequency
    gain0: '0'
    if_gain0: tx_gain
    sample_rate: rf_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pdu_pdu_lambda_0
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda x: pmt.intern(morse_callsign)'
    metadict: Raw Message
  states: {}
- name: pdu_pdu_set_0
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("note")
    v: pmt.intern("beacon")
  states: {}
- name: pdu_pdu_set_1
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("note")
    v: pmt.intern("Received EDL")
  states: {}
- name: pdu_pdu_set_1_0
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("note")
    v: pmt.intern("Pre HDLC Deframe")
  states: {state: disabled}
- name: pdu_pdu_set_2
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("note")
    v: pmt.intern("EDL to send")
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_1_1_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0_1_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_1
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rf_samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"APRS Receive into Demodulator"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rf_samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"EDL Receive into Demodulator"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: rf_samp_rate
    fc: rx_target_frequency
    fftsize: '1024'
    name: '"Translated RF"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rf_samp_rate
    fc: tx_center_frequency
    fftsize: '1024'
    name: '"L Transmit spectrum"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: rf_samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Rx Doppler"'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(rf_samp_rate)
    interp: rx_beacon_bit_rate * samples_per_symbol
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(rf_samp_rate)
    interp: rx_edl_bit_rate * samples_per_symbol
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(tx_bit_rate * samples_per_symbol)
    interp: int(rf_samp_rate)
    taps: ''
    type: ccc
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    short_id: r
    type: intx
    value: '35'
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {state: disabled}
- name: satellites_ax25_deframer_0_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {state: disabled}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: rx_beacon_bit_rate
    iq: 'True'
    samp_rate: rf_samp_rate
    subaudio: 'False'
  states: {state: disabled}
- name: satellites_fsk_demodulator_0_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: rx_edl_bit_rate
    iq: 'True'
    samp_rate: rf_samp_rate
    subaudio: 'False'
  states: {state: disabled}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '300'
  states: {}
- name: satellites_hdlc_deframer_0_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '300'
  states: {}
- name: satellites_hdlc_framer_0_0_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '16'
    preamble_bytes: '32'
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: satellites_nrzi_decode_0_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: satellites_nrzi_encode_0_0_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: satellites_pdu_length_filter_0
  id: satellites_pdu_length_filter
  parameters:
    max: '9'
    min: '9'
  states: {}
- name: satellites_pdu_length_filter_0_0
  id: satellites_pdu_length_filter
  parameters:
    max: '252'
    min: '252'
  states: {}
- name: satellites_pdu_length_filter_1
  id: satellites_pdu_length_filter
  parameters:
    max: '-1'
    min: '1'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      if self.get_tx_selector() == "morse":
          self.set_morse_bump(1)
    section: main_after_start
  states: {}
- name: strobe_delay
  id: parameter
  parameters:
    label: the ms delay between sending EDL commands
    short_id: d
    type: intx
    value: '5000'
  states: {}
- name: tx_bt
  id: parameter
  parameters:
    short_id: g
    type: eng_float
    value: '0.5'
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    short_id: t
    type: intx
    value: '30'
  states: {}
- name: tx_selector
  id: parameter
  parameters:
    label: startup state of TX Selector (cw, edl, morse)
    short_id: s
    type: str
    value: edl
  states: {}
- name: txband
  id: parameter
  parameters:
    short_id: b
    type: str
    value: tx_l
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: IQ_Out
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: EDL_Command
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: IQ_In
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: Beacon
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: EDL_Response
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: HDLC_Frame
  states: {}
- name: virtual_sink_6
  id: virtual_sink
  parameters:
    stream_id: EDL_GFSK
  states: {}
- name: virtual_sink_7
  id: virtual_sink
  parameters:
    stream_id: EDL_complete
  states: {}
- name: virtual_sink_8
  id: virtual_sink
  parameters:
    stream_id: morse_complete
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: IQ_Out
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: EDL_Command
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: IQ_In
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: Beacon
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: EDL_Response
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: HDLC_Frame
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: EDL_GFSK
  states: {}
- name: virtual_source_7
  id: virtual_source
  parameters:
    stream_id: EDL_complete
  states: {}
- name: virtual_source_8
  id: virtual_source
  parameters:
    stream_id: morse_complete
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: '10080'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_2, '0']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_1, '0']
- [analog_sig_source_x_0_1_0, '0', blocks_selector_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0, '0']
- [blocks_file_source_0, '0', virtual_sink_2, '0']
- [blocks_message_strobe_0_0, strobe, satellites_pdu_length_filter_1, in]
- [blocks_multiply_const_vxx_0, '0', limesdr_sink_0_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_mute_xx_1, '0']
- [blocks_multiply_xx_0_1, '0', blocks_mute_xx_0, '0']
- [blocks_mute_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_mute_xx_1, '0', low_pass_filter_0, '0']
- [blocks_mute_xx_1, '0', low_pass_filter_0_0, '0']
- [blocks_mute_xx_1, '0', qtgui_freq_sink_x_1, '0']
- [blocks_null_source_0, '0', virtual_sink_2, '0']
- [blocks_packed_to_unpacked_xx_0_0, '0', blocks_unpacked_to_packed_xx_1_0, '0']
- [blocks_packed_to_unpacked_xx_0_0_0, '0', blocks_unpacked_to_packed_xx_1_0_0, '0']
- [blocks_packed_to_unpacked_xx_0_1_0, '0', blocks_unpacked_to_packed_xx_1_1_0, '0']
- [blocks_selector_0, '0', blocks_multiply_xx_0_1, '1']
- [blocks_tagged_stream_multiply_length_0, '0', digital_burst_shaper_xx_0, '0']
- [blocks_unpacked_to_packed_xx_0_0_0, '0', digital_gfsk_mod_0_0_0, '0']
- [blocks_unpacked_to_packed_xx_1_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_unpacked_to_packed_xx_1_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_unpacked_to_packed_xx_1_1_0, '0', pdu_tagged_stream_to_pdu_0_1_0, '0']
- [blocks_var_to_msg_0, msgout, pdu_pdu_lambda_0, pdu]
- [digital_burst_shaper_xx_0, '0', rational_resampler_xxx_2_0_0_0_0, '0']
- [digital_descrambler_bb_0, '0', satellites_hdlc_deframer_0, '0']
- [digital_descrambler_bb_0_0, '0', pdu_tagged_stream_to_pdu_1, '0']
- [digital_descrambler_bb_0_0, '0', satellites_hdlc_deframer_0_0, '0']
- [digital_gfsk_demod_0, '0', satellites_nrzi_decode_0, '0']
- [digital_gfsk_demod_0_0, '0', satellites_nrzi_decode_0_0, '0']
- [digital_gfsk_demod_0_1, '0', satellites_nrzi_decode_0, '0']
- [digital_gfsk_mod_0_0_0, '0', virtual_sink_6, '0']
- [digital_scrambler_bb_0_0_0, '0', satellites_nrzi_encode_0_0_0, '0']
- [gpredict_doppler_0, freq, blocks_msgpair_to_var_2, inpair]
- [gpredict_doppler_0_0, freq, blocks_msgpair_to_var_0, inpair]
- [gpredict_doppler_0_0, state, blocks_msgpair_to_var_1, inpair]
- [limesdr_source_0, '0', blocks_file_sink_0, '0']
- [limesdr_source_0, '0', virtual_sink_2, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', satellites_fsk_demodulator_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0_0, '0', satellites_fsk_demodulator_0_0, '0']
- [low_pass_filter_0_0_0, '0', virtual_sink_7, '0']
- [morse_hier_0, '0', virtual_sink_8, '0']
- [network_socket_pdu_0_0_0_0, pdus, virtual_sink_1, '0']
- [pdu_pdu_lambda_0, pdu, morse_hier_0, msg_in]
- [pdu_pdu_set_0, pdus, blocks_message_debug_0, print]
- [pdu_pdu_set_1, pdus, blocks_message_debug_0_0, print]
- [pdu_pdu_set_1_0, pdus, blocks_message_debug_0_0, print]
- [pdu_pdu_set_2, pdus, blocks_message_debug_0_0_0_0_0_0_1_0, print]
- [pdu_pdu_to_tagged_stream_0_0_0, '0', virtual_sink_5, '0']
- [pdu_pdu_to_tagged_stream_1_0, '0', blocks_packed_to_unpacked_xx_0_0, '0']
- [pdu_pdu_to_tagged_stream_1_0_0, '0', blocks_packed_to_unpacked_xx_0_0_0, '0']
- [pdu_pdu_to_tagged_stream_1_1_0, '0', blocks_packed_to_unpacked_xx_0_1_0, '0']
- [pdu_tagged_stream_to_pdu_0_0, pdus, satellites_pdu_length_filter_0, in]
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, blocks_message_debug_0_0_0, print]
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, network_socket_pdu_0_1_0, pdus]
- [pdu_tagged_stream_to_pdu_0_1_0, pdus, satellites_hdlc_framer_0_0_0, in]
- [pdu_tagged_stream_to_pdu_1, pdus, pdu_pdu_set_1_0, pdus]
- [rational_resampler_xxx_0, '0', digital_gfsk_demod_0, '0']
- [rational_resampler_xxx_0, '0', digital_gfsk_demod_0_1, '0']
- [rational_resampler_xxx_0_0, '0', digital_gfsk_demod_0_0, '0']
- [rational_resampler_xxx_2_0_0_0_0, '0', low_pass_filter_0_0_0, '0']
- [satellites_ax25_deframer_0, out, blocks_message_debug_0_1, print]
- [satellites_ax25_deframer_0, out, network_socket_pdu_0_2, pdus]
- [satellites_ax25_deframer_0_0, out, pdu_pdu_to_tagged_stream_1_0_0, pdus]
- [satellites_fsk_demodulator_0, '0', satellites_ax25_deframer_0, '0']
- [satellites_fsk_demodulator_0_0, '0', satellites_ax25_deframer_0_0, '0']
- [satellites_hdlc_deframer_0, out, satellites_pdu_length_filter_0_0, in]
- [satellites_hdlc_deframer_0_0, out, pdu_pdu_to_tagged_stream_1_0, pdus]
- [satellites_hdlc_framer_0_0_0, out, blocks_message_debug_0_0_0_0_0_0_0_0_0, print]
- [satellites_hdlc_framer_0_0_0, out, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [satellites_nrzi_decode_0, '0', digital_descrambler_bb_0, '0']
- [satellites_nrzi_decode_0_0, '0', digital_descrambler_bb_0_0, '0']
- [satellites_nrzi_encode_0_0_0, '0', blocks_unpacked_to_packed_xx_0_0_0, '0']
- [satellites_pdu_length_filter_0, out, pdu_pdu_set_1, pdus]
- [satellites_pdu_length_filter_0, out, virtual_sink_4, '0']
- [satellites_pdu_length_filter_0_0, out, pdu_pdu_set_0, pdus]
- [satellites_pdu_length_filter_0_0, out, virtual_sink_3, '0']
- [satellites_pdu_length_filter_1, out, virtual_sink_1, '0']
- [virtual_source_0, '0', blocks_file_sink_0_0, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', osmosdr_sink_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_1_0_0_0, '0']
- [virtual_source_1, '0', pdu_pdu_set_2, pdus]
- [virtual_source_1, '0', pdu_pdu_to_tagged_stream_1_1_0, pdus]
- [virtual_source_2, '0', blocks_multiply_xx_0, '0']
- [virtual_source_3, '0', network_socket_pdu_0, pdus]
- [virtual_source_4, '0', network_socket_pdu_0_1, pdus]
- [virtual_source_5, '0', digital_scrambler_bb_0_0_0, '0']
- [virtual_source_6, '0', blocks_tagged_stream_multiply_length_0, '0']
- [virtual_source_7, '0', blocks_selector_0, '1']
- [virtual_source_8, '0', blocks_selector_0, '2']

metadata:
  file_format: 1
