options:
  parameters:
    catch_exceptions: 'False'
    comment: |-
      ~
      See:
      https://github.com/oresat/uniclogs-sdr/flowgraphs
    generate_options: no_gui
    id: OreSat1
    output_language: python
    run_options: run
    title: UHF G3RUH & EDL Receiver / UHF -or- L-Band EDL Transmitter
  states: {}

blocks:
- name: SFD0
  id: variable
  parameters:
    value: '[0x90, 0x4e]'
  states: {}
- name: SFD1
  id: variable
  parameters:
    value: '[0x6F, 0x4e]'
  states: {}
- name: beacon_host
  id: variable_config
  parameters:
    config_file: conf
    option: telemetry_host
    section: main
    type: string
    value: localhost
    writeback: None
  states: {}
- name: device_serial
  id: variable_config
  parameters:
    config_file: conf
    option: '"device_serial"'
    section: main
    type: string
    value: ''
    writeback: None
  states: {}
- name: edl_host
  id: variable_config
  parameters:
    config_file: conf
    option: command_host
    section: main
    type: string
    value: localhost
    writeback: None
  states: {}
- name: f_offset
  id: variable
  parameters:
    comment: |-
      Pick out our RF
      carrier in the Rx
      bandwidth
    value: rx_samp_rate/4
  states: {}
- name: gpredict_rx_frequency
  id: variable
  parameters:
    comment: doppler correction passed through from pass commander
    value: rx_target_frequency
  states: {}
- name: gpredict_tx_frequency
  id: variable
  parameters:
    value: tx_center_frequency
  states: {}
- name: ieee_encoder
  id: uniclogs_variable_ieee802_15_4_encoder
  parameters:
    frame_len: '240'
    preamble: '0x55'
    preamble_len: '8'
    sync_word: '[0x72, 0x09]'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[0b0101_0101]*8'
  states: {}
- name: rx_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: rx_beacon
    type: int
    value: '50000'
    writeback: None
  states: {}
- name: rx_gain
  id: variable_config
  parameters:
    config_file: conf
    option: gain
    section: rx
    type: int
    value: '35'
    writeback: None
  states: {}
- name: rx_iq_data_filename
  id: variable_config
  parameters:
    config_file: conf
    option: iq_filename
    section: rx
    type: string
    value: delete_me.iq
    writeback: None
  states: {}
- name: rx_samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rx_samp_rate
  id: variable_config
  parameters:
    comment: |-
      Dividing SDR clock rate
      by this should result in
      an even integer for best
      decimation
    config_file: conf
    option: sample_rate
    section: rx
    type: real
    value: 2e6
    writeback: None
  states: {}
- name: rx_symb_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: rx_beacon
    type: int
    value: '50000'
    writeback: None
  states: {}
- name: rx_target_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: target_frequency
    section: rx
    type: real
    value: 436.5e6
    writeback: None
  states: {}
- name: rx_tune_frequency
  id: variable
  parameters:
    value: rx_target_frequency - f_offset
  states: {}
- name: sample_decimation_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: tx_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: txband
    type: int
    value: '50000'
    writeback: None
  states: {}
- name: tx_bt
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: tx_center_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: center_frequency
    section: txband
    type: real
    value: 1265e6
    writeback: None
  states: {}
- name: tx_lo_offset
  id: variable
  parameters:
    comment: |-
      Deviation * 4
      MSK m=0.5
    value: 2 * tx_bit_rate
  states: {}
- name: tx_samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: tx_samp_per_sym * tx_bit_rate
  states: {}
- name: uniclogs_ieee802_15_4_variant_decoder_0
  id: uniclogs_ieee802_15_4_variant_decoder
  parameters:
    preamble: preamble
    preamble_thrsh: '5'
    sync_thrsh: '1'
    sync_word: SFD0
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      Will generate empty file
      when not in use
    file: rx_iq_data_filename
    type: complex
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    comment: Doppler Correction
    freq: gpredict_tx_frequency - tx_center_frequency
    sample_rate: tx_samp_rate
  states: {}
- name: blocks_freqshift_cc_1
  id: blocks_freqshift_cc
  parameters:
    comment: |-
      Doppler Correction and LO offset
      Shifting 436.5 IQ to 436
    freq: rx_tune_frequency - gpredict_rx_frequency
    sample_rate: rx_samp_rate
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    comment: Recovered APRS
  states: {}
- name: blocks_message_debug_0_0_0_0_0_0_1_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    comment: |-
      Mutes IQ data (does not
      save to file) if filename is
      blank
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: int(rx_iq_data_filename != 'delete_me.iq')
    type: complex
  states: {}
- name: conf
  id: parameter
  parameters:
    label: config file
    short_id: c
    type: str
    value: OreSat05.cfg
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_gfsk_demod_0_0_1
  id: digital_gfsk_demod
  parameters:
    comment: |-
      Sensitivity from 
      textbook (whch ???)

      old gain is 0.175
      (2 * rx_samp_per_sym) / np.pi
    freq_error: '0.0'
    gain_mu: '0.175'
    log: 'True'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: '4'
    sensitivity: rx_samp_rate / (2*np.pi*rx_symb_rate)
    verbose: 'True'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: 'tx_bt '
    do_unpack: 'False'
    samples_per_symbol: tx_samp_per_sym
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0_0_1
  id: low_pass_filter
  parameters:
    comment: |-
      Also does some
      decimation
    cutoff_freq: rx_symb_rate*1.5
    decim: sample_decimation_rate
    gain: '1'
    samp_rate: rx_samp_rate
    type: fir_filter_ccf
    width: rx_symb_rate*0.75
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    comment: Received APRS beacon
    host: beacon_host
    mtu: '10000'
    port: '10015'
    type: UDP_CLIENT
  states: {}
- name: network_socket_pdu_0_0_0_0_0
  id: network_socket_pdu
  parameters:
    comment: EDL uplink
    mtu: '10000'
    port: '10025'
    type: UDP_SERVER
  states: {}
- name: note_0
  id: note
  parameters:
    note: TX path here
  states: {}
- name: note_1
  id: note
  parameters:
    note: master clock needs to be a multiple of both TX and RX sample rates
  states: {}
- name: note_4
  id: note
  parameters:
    note: RX path here
  states: {}
- name: pdu_pdu_set_0_0
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("note")
    v: pmt.intern("beacon")
  states: {}
- name: pdu_pdu_set_2
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("note")
    v: pmt.intern("EDL to send")
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    short_id: t
    type: intx
    value: '1'
  states: {}
- name: txband
  id: parameter
  parameters:
    short_id: b
    type: str
    value: tx_l
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: uhd.tune_request(tx_center_frequency, tx_lo_offset)
    dev_addr: '"serial="+device_serial'
    gain0: tx_gain
    len_tag_name: packet_len
    samp_rate: tx_samp_rate
    show_lo_controls: 'True'
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: rx_tune_frequency
    comment: From the Ettus B200mini
    dev_addr: '"serial="+device_serial'
    gain0: rx_gain
    samp_rate: rx_samp_rate
    show_lo_controls: 'True'
    sync: pc_clock
    type: fc32
  states: {}
- name: uniclogs_frame_decoder_0
  id: uniclogs_frame_decoder
  parameters:
    decoder_object: uniclogs_ieee802_15_4_variant_decoder_0
    itype: byte
    vlen: '1'
  states: {}
- name: uniclogs_frame_encoder_0
  id: uniclogs_frame_encoder
  parameters:
    encoder_object: ieee_encoder
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    comment: |-
      Pass commander server that
      passes a doppler correction
    port: '10080'
  states: {}

connections:
- [blocks_freqshift_cc_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_freqshift_cc_1, '0', blocks_selector_1, '0']
- [blocks_freqshift_cc_1, '0', low_pass_filter_0_0_1, '0']
- [blocks_selector_1, '0', blocks_null_sink_1, '0']
- [blocks_selector_1, '1', blocks_file_sink_0, '0']
- [digital_crc_append_0, out, uniclogs_frame_encoder_0, pdu]
- [digital_gfsk_demod_0_0_1, '0', uniclogs_frame_decoder_0, '0']
- [digital_gmsk_mod_0, '0', blocks_freqshift_cc_0, '0']
- [low_pass_filter_0_0_1, '0', digital_gfsk_demod_0_0_1, '0']
- [network_socket_pdu_0_0_0_0_0, pdus, digital_crc_append_0, in]
- [network_socket_pdu_0_0_0_0_0, pdus, pdu_pdu_set_2, pdus]
- [pdu_pdu_set_0_0, pdus, blocks_message_debug_0_0, print]
- [pdu_pdu_set_2, pdus, blocks_message_debug_0_0_0_0_0_0_1_0, print]
- [pdu_pdu_to_stream_x_0, '0', digital_gmsk_mod_0, '0']
- [uhd_usrp_sink_0_0, async_msgs, blocks_message_debug_1, print]
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_1, '0']
- [uniclogs_frame_decoder_0, out, network_socket_pdu_0_0, pdus]
- [uniclogs_frame_decoder_0, out, pdu_pdu_set_0_0, pdus]
- [uniclogs_frame_encoder_0, pdu, blocks_message_debug_1_0, print]
- [uniclogs_frame_encoder_0, pdu, pdu_pdu_to_stream_x_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
