options:
  parameters:
    author: GlennL & KennyM
    catch_exceptions: 'False'
    comment: |-
      ~
      See:
      https://github.com/oresat/uniclogs-sdr/flowgraphs
    generate_options: no_gui
    id: OreSat05
    output_language: python
    run_options: run
    title: UHF G3RUH & EDL Receiver / UHF -or- L-Band EDL Transmitter
  states: {}

blocks:
- name: beacon_host
  id: variable_config
  parameters:
    config_file: conf
    option: telemetry_host
    section: main
    type: string
    value: localhost
    writeback: None
  states: {}
- name: device_serial
  id: variable_config
  parameters:
    config_file: conf
    option: '"device_serial"'
    section: main
    type: string
    value: ''
    writeback: None
  states: {}
- name: edl_host
  id: variable_config
  parameters:
    config_file: conf
    option: command_host
    section: main
    type: string
    value: localhost
    writeback: None
  states: {}
- name: f_offset
  id: variable
  parameters:
    comment: |-
      Pick out our RF
      carrier in the Rx
      bandwidth
    value: rx_samp_rate/4
  states: {}
- name: gpredict_rx_frequency
  id: variable
  parameters:
    comment: doppler correction passed through from pass commander
    value: rx_target_frequency
  states: {}
- name: gpredict_tx_frequency
  id: variable
  parameters:
    value: tx_center_frequency
  states: {}
- name: rx_beacon_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: rx_beacon
    type: int
    value: '50000'
    writeback: None
  states: {}
- name: rx_edl_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: rx_edl
    type: int
    value: '96000'
    writeback: None
  states: {}
- name: rx_gain
  id: variable_config
  parameters:
    config_file: conf
    option: gain
    section: rx
    type: int
    value: '35'
    writeback: None
  states: {}
- name: rx_iq_data_filename
  id: variable_config
  parameters:
    config_file: conf
    option: iq_filename
    section: rx
    type: string
    value: delete_me.iq
    writeback: None
  states: {}
- name: rx_samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rx_samp_rate
  id: variable_config
  parameters:
    comment: |-
      Dividing SDR clock rate
      by this should result in
      an even integer for best
      decimation
    config_file: conf
    option: sample_rate
    section: rx
    type: real
    value: 2e6
    writeback: None
  states: {}
- name: rx_target_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: target_frequency
    section: rx
    type: real
    value: 436.5e6
    writeback: None
  states: {}
- name: rx_tune_frequency
  id: variable
  parameters:
    value: rx_target_frequency - f_offset
  states: {}
- name: sample_decimation_rate
  id: variable
  parameters:
    value: '20'
  states: {}
- name: tx_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: txband
    type: int
    value: '60000'
    writeback: None
  states: {}
- name: tx_bt
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: tx_center_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: center_frequency
    section: txband
    type: real
    value: 1265e6
    writeback: None
  states: {}
- name: tx_lo_offset
  id: variable
  parameters:
    comment: |-
      Deviation * 4
      MSK m=0.5
    value: 2 * tx_bit_rate
  states: {}
- name: tx_samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: tx_samp_per_sym * tx_bit_rate
  states: {}
- name: analog_sig_source_x_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: CW test source
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: tx_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      Will generate empty file
      when not in use
    file: rx_iq_data_filename
    type: complex
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    comment: Doppler Correction
    freq: gpredict_tx_frequency - tx_center_frequency
    sample_rate: tx_samp_rate
  states: {state: bypassed}
- name: blocks_freqshift_cc_1
  id: blocks_freqshift_cc
  parameters:
    comment: |-
      Doppler Correction and LO offset
      Shifting 436.5 IQ to 436
    freq: rx_tune_frequency - gpredict_rx_frequency
    sample_rate: rx_samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Recovered APRS
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '[''cw'', ''edl'', ''morse''].index(tx_selector)'
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    comment: |-
      Mutes IQ data (does not
      save to file) if filename is
      blank
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: int(rx_iq_data_filename != 'delete_me.iq')
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: tx_samp_per_sym
    lengthtagname: packet_len
    type: complex
  states: {}
- name: conf
  id: parameter
  parameters:
    label: config file
    short_id: c
    type: str
    value: OreSat05.cfg
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '101010'
    type: byte
  states: {}
- name: digital_descrambler_bb_0_0
  id: digital_descrambler_bb
  parameters:
    comment: |-
      https://destevez.net/2016/05/
      scramblers-and-their-implementation-in-gnuradio/
    len: '30'
    mask: '0x0021'
    seed: '0xFFFF'
  states: {state: disabled}
- name: digital_gfsk_demod_0_0_0
  id: digital_gfsk_demod
  parameters:
    comment: |-
      Sensitivity from 
      textbook (whch ???)
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: rx_samp_per_sym
    sensitivity: 2 * rx_samp_per_sym / np.pi
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: 'tx_bt '
    do_unpack: 'False'
    samples_per_symbol: tx_samp_per_sym
  states: {}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters: {}
  states: {}
- name: digital_scrambler_bb_0_0_0_0
  id: digital_scrambler_bb
  parameters:
    comment: |-
      https://destevez.net/2016/05/
      scramblers-and-their-implementation-in-gnuradio/
      See also AX5043 PM Fig. 17/18
    len: '30'
    mask: '0x21'
    seed: '0xFFFF'
  states: {state: disabled}
- name: fec_tagged_decoder_0
  id: fec_tagged_decoder
  parameters:
    decoder: decoder_variable
    lentagname: '"pkt_len"'
    mtu: '1500'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    comment: |-
      Also does some
      pre-decimation
    cutoff_freq: rx_edl_bit_rate*1.5
    decim: sample_decimation_rate
    gain: '1'
    samp_rate: rx_samp_rate
    type: fir_filter_ccf
    width: rx_edl_bit_rate*0.75
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '10015'
    type: UDP_CLIENT
  states: {}
- name: network_socket_pdu_0_0_0_0
  id: network_socket_pdu
  parameters:
    comment: EDL uplink
    mtu: '10000'
    port: '10025'
    type: UDP_SERVER
  states: {}
- name: note_0
  id: note
  parameters:
    note: TX path here
  states: {}
- name: note_1
  id: note
  parameters:
    note: master clock needs to be a multiple of both TX and RX sample rates
  states: {}
- name: note_4
  id: note
  parameters:
    note: RX path here
  states: {}
- name: pdu_pdu_set_0
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("note")
    v: pmt.intern("beacon")
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: tx_samp_rate
    fc: tx_center_frequency
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '5000'
    srate: tx_samp_rate
    type: complex
  states: {state: disabled}
- name: tx_gain
  id: parameter
  parameters:
    short_id: t
    type: intx
    value: '1'
  states: {}
- name: txband
  id: parameter
  parameters:
    short_id: b
    type: str
    value: tx_l
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: uhd.tune_request(tx_center_frequency, tx_lo_offset)
    dev_addr: '"serial="+device_serial'
    gain0: tx_gain
    len_tag_name: packet_len
    samp_rate: tx_samp_rate
    show_lo_controls: 'True'
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: rx_tune_frequency
    comment: From the Ettus B200mini
    dev_addr: '"serial="+device_serial'
    gain0: rx_gain
    samp_rate: rx_samp_rate
    show_lo_controls: 'True'
    sync: pc_clock
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    comment: |-
      Pass commander server that
      passes a doppler correction
    port: '10080'
  states: {}

connections:
- [analog_sig_source_x_0_1_0, '0', blocks_selector_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_tag_debug_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_freqshift_cc_1, '0', blocks_selector_1, '0']
- [blocks_freqshift_cc_1, '0', low_pass_filter_0_0_0, '0']
- [blocks_selector_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_selector_1, '0', blocks_null_sink_1, '0']
- [blocks_selector_1, '1', blocks_file_sink_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', blocks_selector_0, '1']
- [digital_correlate_access_code_tag_xx_0, '0', digital_protocol_parser_b_0, '0']
- [digital_descrambler_bb_0_0, '0', blocks_deinterleave_0, '0']
- [digital_gfsk_demod_0_0_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_gmsk_mod_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']
- [low_pass_filter_0_0_0, '0', digital_gfsk_demod_0_0_0, '0']
- [pdu_pdu_set_0, pdus, blocks_message_debug_0, print]
- [uhd_usrp_sink_0_0, async_msgs, blocks_message_debug_1, print]
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
