options:
  parameters:
    author: GlennL & KennyM
    catch_exceptions: 'False'
    comment: |-
      ~
      See:
      https://github.com/oresat/uniclogs-sdr/flowgraphs
    generate_options: no_gui
    id: OreSat05
    output_language: python
    run_options: run
    title: UHF G3RUH & EDL Receiver / UHF -or- L-Band EDL Transmitter
  states: {}

blocks:
- name: beacon_filt_decimation
  id: variable
  parameters:
    value: '20'
  states: {}
- name: beacon_host
  id: variable_config
  parameters:
    config_file: conf
    option: telemetry_host
    section: main
    type: string
    value: localhost
    writeback: None
  states: {}
- name: device_serial
  id: variable_config
  parameters:
    config_file: conf
    option: '"device_serial"'
    section: main
    type: string
    value: ''
    writeback: None
  states: {}
- name: edl_filt_decimation
  id: variable
  parameters:
    value: '2'
  states: {}
- name: edl_host
  id: variable_config
  parameters:
    config_file: conf
    option: command_host
    section: main
    type: string
    value: localhost
    writeback: None
  states: {}
- name: f_offset
  id: variable
  parameters:
    comment: |-
      Pick out our RF
      carrier in the Rx
      bandwidth
    value: rx_samp_rate/4
  states: {}
- name: gpredict_rx_frequency
  id: variable
  parameters:
    value: rx_target_frequency
  states: {}
- name: gpredict_tx_frequency
  id: variable
  parameters:
    value: tx_center_frequency
  states: {}
- name: morse_ident
  id: variable
  parameters:
    value: None
  states: {}
- name: rx_beacon_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: rx_beacon
    type: int
    value: '9600'
    writeback: None
  states: {}
- name: rx_edl_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: rx_edl
    type: int
    value: '96000'
    writeback: None
  states: {}
- name: rx_gain
  id: variable_config
  parameters:
    config_file: conf
    option: gain
    section: rx
    type: int
    value: '35'
    writeback: None
  states: {}
- name: rx_iq_data_filename
  id: variable_config
  parameters:
    config_file: conf
    option: iq_filename
    section: rx
    type: string
    value: ''
    writeback: None
  states: {}
- name: rx_samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rx_samp_rate
  id: variable_config
  parameters:
    comment: |-
      Dividing SDR clock rate
      by this should result in
      an even integer for best
      decimation
    config_file: conf
    option: sample_rate
    section: rx
    type: real
    value: 2e6
    writeback: None
  states: {}
- name: rx_target_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: target_frequency
    section: rx
    type: real
    value: 436.5e6
    writeback: None
  states: {}
- name: rx_tune_frequency
  id: variable
  parameters:
    value: rx_target_frequency - f_offset
  states: {}
- name: tx_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: txband
    type: int
    value: '60000'
    writeback: None
  states: {}
- name: tx_bt
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: tx_center_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: center_frequency
    section: txband
    type: real
    value: 1265e6
    writeback: None
  states: {}
- name: tx_lo_offset
  id: variable
  parameters:
    comment: |-
      Deviation * 4
      MSK m=0.5
    value: 2 * tx_bit_rate
  states: {}
- name: tx_samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: tx_samp_per_sym * tx_bit_rate
  states: {}
- name: analog_sig_source_x_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: CW test source
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: tx_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Option to save IQ data
    file: rx_iq_data_filename
    type: complex
  states: {state: disabled}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    comment: Doppler Correction
    freq: gpredict_tx_frequency - tx_center_frequency
    sample_rate: tx_samp_rate
  states: {}
- name: blocks_freqshift_cc_1
  id: blocks_freqshift_cc
  parameters:
    comment: |-
      Doppler Correction and
      LO offset
    freq: rx_tune_frequency - gpredict_rx_frequency
    sample_rate: rx_samp_rate
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Recovered APRS
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    comment: Recovered EDL
  states: {state: disabled}
- name: blocks_message_debug_0_0_0_0_0_0_1_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: gpredict_tx_frequency
  states: {}
- name: blocks_msgpair_to_var_2
  id: blocks_msgpair_to_var
  parameters:
    target: gpredict_rx_frequency
  states: {}
- name: blocks_mute_xx_0_0
  id: blocks_mute_xx
  parameters:
    comment: |-
      Mute IQ data (do not save 
      to file) if filename is blank
    mute: bool(rx_iq_data_filename)
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    comment: Reverse bit order
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '8'
  states: {state: disabled}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '[''cw'', ''edl'', ''morse''].index(tx_selector)'
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: See morse_hier.morse_sps
    len_tag_key: '"packet_len"'
    packet_len: len(morse_ident or []) * int(60 * tx_samp_rate / 50 / 20)
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: tx_samp_per_sym
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: int(rx_samp_rate)/tx_samp_rate
    lengthtagname: packet_len
    type: complex
  states: {state: disabled}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: ''
    target: morse_ident
  states: {}
- name: conf
  id: parameter
  parameters:
    label: config file
    short_id: c
    type: str
    value: OreSat05.cfg
  states: {}
- name: digital_descrambler_bb_0_0
  id: digital_descrambler_bb
  parameters:
    comment: |-
      https://destevez.net/2016/05/
      scramblers-and-their-implementation-in-gnuradio/
    len: '16'
    mask: '0x0021'
    seed: '0x0000'
  states: {state: disabled}
- name: digital_descrambler_bb_0_0_0
  id: digital_descrambler_bb
  parameters:
    comment: |-
      https://destevez.net/2016/05/
      scramblers-and-their-implementation-in-gnuradio/
    len: '16'
    mask: '0x0021'
    seed: '0x0000'
  states: {state: disabled}
- name: digital_gfsk_demod_0_0
  id: digital_gfsk_demod
  parameters:
    comment: |-
      Sensitivity from 
      textbook (whch ???)
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: rx_samp_per_sym
    sensitivity: 2 * rx_samp_per_sym / np.pi
  states: {state: disabled}
- name: digital_gfsk_demod_0_0_0
  id: digital_gfsk_demod
  parameters:
    comment: |-
      Sensitivity from 
      textbook (whch ???)
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: rx_samp_per_sym
    sensitivity: 2 * rx_samp_per_sym / np.pi
  states: {state: disabled}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: 'tx_bt '
    do_unpack: 'False'
    samples_per_symbol: tx_samp_per_sym
  states: {}
- name: digital_scrambler_bb_0_0_0_0
  id: digital_scrambler_bb
  parameters:
    comment: |-
      https://destevez.net/2016/05/
      scramblers-and-their-implementation-in-gnuradio/
      See also AX5043 PM Fig. 17/18
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    comment: |-
      Update RX frequency w/Doppler
      via XMLRPC
    gpredict_host: 0.0.0.0
    gpredict_port: '7356'
    verbose: 'False'
  states: {}
- name: gpredict_doppler_0_0
  id: gpredict_doppler
  parameters:
    comment: TX doppler
    gpredict_host: 0.0.0.0
    gpredict_port: '7358'
    verbose: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    comment: |-
      Also does some
      pre-decimation
    cutoff_freq: rx_beacon_bit_rate*1.5
    decim: beacon_filt_decimation
    gain: '1'
    samp_rate: rx_samp_rate
    type: fir_filter_ccf
    width: rx_beacon_bit_rate*0.75
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    comment: |-
      Also does some
      pre-decimation
    cutoff_freq: rx_edl_bit_rate*1.5
    decim: edl_filt_decimation
    gain: '1'
    samp_rate: rx_samp_rate
    type: fir_filter_ccf
    width: rx_edl_bit_rate*0.75
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: morse_hier_0
  id: morse_hier
  parameters:
    morse_dpw: '50'
    morse_wpm: '20'
    rf_samp_rate: tx_samp_rate
    verbose: 'True'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    comment: Received APRS beacon
    host: beacon_host
    mtu: '10000'
    port: '10015'
    type: UDP_CLIENT
  states: {state: disabled}
- name: network_socket_pdu_0_0_0_0
  id: network_socket_pdu
  parameters:
    comment: EDL uplink
    mtu: '10000'
    port: '10025'
    type: UDP_SERVER
  states: {}
- name: network_socket_pdu_0_1
  id: network_socket_pdu
  parameters:
    comment: Received EDL response
    host: edl_host
    mtu: '10000'
    port: '10016'
    type: UDP_CLIENT
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: TX path here
  states: {}
- name: note_2
  id: note
  parameters:
    note: FIXME LO offset via command
  states: {}
- name: note_3
  id: note
  parameters:
    note: Beacon path
  states: {}
- name: note_4
  id: note
  parameters:
    note: RX path here
  states: {}
- name: note_5
  id: note
  parameters:
    note: EDL path
  states: {}
- name: pdu_pdu_lambda_0
  id: pdu_pdu_lambda
  parameters:
    comment: |-
      Converts morse_ident to pdu
      Is there a better way?
    fn: 'lambda x: pmt.intern(morse_ident)'
    metadict: Raw Message
  states: {}
- name: pdu_pdu_lambda_1
  id: pdu_pdu_lambda
  parameters:
    comment: Reverse bit order
    fn: 'lambda x: np.packbits(np.unpackbits(x, bitorder=''little''))'
    metadict: Uniform Vector
  states: {}
- name: pdu_pdu_set_0
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("note")
    v: pmt.intern("beacon")
  states: {state: disabled}
- name: pdu_pdu_set_1
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("note")
    v: pmt.intern("Received EDL")
  states: {state: disabled}
- name: pdu_pdu_set_2
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("note")
    v: pmt.intern("EDL to send")
  states: {}
- name: pdu_pdu_set_3_1
  id: pdu_pdu_set
  parameters:
    comment: |-
      surely there has to be a
      better way
    k: pmt.intern("tx_time")
    v: '[pmt.make_tuple(pmt.from_uint64(t.get_full_secs()), pmt.from_double(t.get_frac_secs())) for t in [uhd.time_spec(time.time()) + uhd.time_spec(0.1)]][0]'
  states: {state: bypassed}
- name: pdu_pdu_set_3_1_0
  id: pdu_pdu_set
  parameters:
    comment: |-
      surely there has to be a
      better way
    k: pmt.intern("tx_time")
    v: '[pmt.make_tuple(pmt.from_uint64(t.get_full_secs()), pmt.from_double(t.get_frac_secs())) for t in [uhd.time_spec(time.time()) + uhd.time_spec(0.01)]][0]'
  states: {state: bypassed}
- name: pdu_pdu_to_tagged_stream_0_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: tx_samp_rate
    fc: tx_center_frequency
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '5000'
    srate: tx_samp_rate
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: tx_samp_rate
    interp: int(rx_samp_rate)
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Can this just do the
      low pass filtering in
      one step?
    decim: int(rx_samp_rate)//beacon_filt_decimation
    interp: rx_beacon_bit_rate * rx_samp_per_sym
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(rx_samp_rate)//edl_filt_decimation
    interp: rx_edl_bit_rate * rx_samp_per_sym
    taps: ''
    type: ccc
  states: {state: disabled}
- name: satellites_hdlc_deframer_0_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    comment: Make PDUs
    max_length: '300'
  states: {state: disabled}
- name: satellites_hdlc_deframer_0_0_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '300'
  states: {state: disabled}
- name: satellites_hdlc_framer_0_0_0_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '16'
    preamble_bytes: '32'
  states: {}
- name: satellites_nrzi_decode_0_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {state: disabled}
- name: satellites_nrzi_decode_0_0_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {state: disabled}
- name: satellites_nrzi_encode_0_0_0_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    short_id: t
    type: intx
    value: '1'
  states: {}
- name: tx_selector
  id: parameter
  parameters:
    comment: one of  'cw', 'edl', 'morse'
    label: startup state of TX Selector (cw, edl, morse)
    short_id: s
    type: str
    value: edl
  states: {}
- name: txband
  id: parameter
  parameters:
    short_id: b
    type: str
    value: tx_l
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: uhd.tune_request(tx_center_frequency, tx_lo_offset)
    dev_addr: '"serial="+device_serial'
    gain0: tx_gain
    len_tag_name: packet_len
    samp_rate: tx_samp_rate
    show_lo_controls: 'True'
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: uhd.tune_request(tx_center_frequency, tx_lo_offset)
    dev_addr: '"serial="+device_serial'
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: tx_samp_rate
    show_lo_controls: 'True'
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: rx_tune_frequency
    comment: From the Ettus B200mini
    dev_addr: '"serial="+device_serial'
    gain0: rx_gain
    samp_rate: rx_samp_rate
    show_lo_controls: 'True'
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: '10080'
  states: {}

connections:
- [analog_sig_source_x_0_1_0, '0', blocks_selector_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_tag_debug_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', uhd_usrp_sink_0, '0']
- [blocks_freqshift_cc_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_freqshift_cc_1, '0', blocks_mute_xx_0_0, '0']
- [blocks_freqshift_cc_1, '0', low_pass_filter_0_0, '0']
- [blocks_freqshift_cc_1, '0', low_pass_filter_0_0_0, '0']
- [blocks_mute_xx_0_0, '0', blocks_file_sink_0, '0']
- [blocks_repack_bits_bb_0, '0', satellites_hdlc_deframer_0_0_0, '0']
- [blocks_selector_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_selector_0, '2']
- [blocks_tagged_stream_multiply_length_0_0, '0', blocks_selector_0, '1']
- [blocks_var_to_msg_0, msgout, pdu_pdu_lambda_0, pdu]
- [digital_descrambler_bb_0_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_descrambler_bb_0_0_0, '0', satellites_hdlc_deframer_0_0, '0']
- [digital_gfsk_demod_0_0, '0', satellites_nrzi_decode_0_0, '0']
- [digital_gfsk_demod_0_0_0, '0', satellites_nrzi_decode_0_0_0, '0']
- [digital_gmsk_mod_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']
- [digital_scrambler_bb_0_0_0_0, '0', satellites_nrzi_encode_0_0_0_0, '0']
- [gpredict_doppler_0, freq, blocks_msgpair_to_var_2, inpair]
- [gpredict_doppler_0_0, freq, blocks_msgpair_to_var_0, inpair]
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [morse_hier_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [network_socket_pdu_0_0_0_0, pdus, pdu_pdu_lambda_1, pdu]
- [network_socket_pdu_0_0_0_0, pdus, pdu_pdu_set_2, pdus]
- [pdu_pdu_lambda_0, pdu, pdu_pdu_set_3_1_0, pdus]
- [pdu_pdu_lambda_1, pdu, satellites_hdlc_framer_0_0_0_0, in]
- [pdu_pdu_set_0, pdus, blocks_message_debug_0, print]
- [pdu_pdu_set_1, pdus, blocks_message_debug_0_0, print]
- [pdu_pdu_set_2, pdus, blocks_message_debug_0_0_0_0_0_0_1_0, print]
- [pdu_pdu_set_3_1, pdus, pdu_pdu_to_tagged_stream_0_0_0_0, pdus]
- [pdu_pdu_set_3_1_0, pdus, morse_hier_0, msg_in]
- [pdu_pdu_to_tagged_stream_0_0_0_0, '0', digital_scrambler_bb_0_0_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_tag_debug_0, '0']
- [rational_resampler_xxx_0, '0', blocks_tagged_stream_multiply_length_0_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', digital_gfsk_demod_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', digital_gfsk_demod_0_0_0, '0']
- [satellites_hdlc_deframer_0_0, out, network_socket_pdu_0, pdus]
- [satellites_hdlc_deframer_0_0, out, pdu_pdu_set_0, pdus]
- [satellites_hdlc_deframer_0_0_0, out, network_socket_pdu_0_1, pdus]
- [satellites_hdlc_deframer_0_0_0, out, pdu_pdu_set_1, pdus]
- [satellites_hdlc_framer_0_0_0_0, out, pdu_pdu_set_3_1, pdus]
- [satellites_nrzi_decode_0_0, '0', digital_descrambler_bb_0_0_0, '0']
- [satellites_nrzi_decode_0_0_0, '0', digital_descrambler_bb_0_0, '0']
- [satellites_nrzi_encode_0_0_0_0, '0', digital_gmsk_mod_0, '0']
- [uhd_usrp_sink_0, async_msgs, blocks_message_debug_1, print]
- [uhd_usrp_sink_0_0, async_msgs, blocks_message_debug_1, print]
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_1, '0']
- [uhd_usrp_source_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
