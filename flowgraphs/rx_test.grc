options:
  parameters:
    generate_options: no_gui
    id: rx_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: SFD0
  id: variable
  parameters:
    value: '[0x90, 0x4e]'
  states: {}
- name: SFD1
  id: variable
  parameters:
    value: '[0x6F, 0x4e]'
  states: {}
- name: device_serial
  id: variable_config
  parameters:
    config_file: conf
    option: '"device_serial"'
    section: main
    type: string
    value: ''
    writeback: None
  states: {}
- name: f_offset
  id: variable
  parameters:
    comment: |-
      Pick out our RF
      carrier in the Rx
      bandwidth
    value: rx_samp_rate/4
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[0b0101_0101]*8'
  states: {}
- name: rx_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: rx_beacon
    type: int
    value: '50000'
    writeback: None
  states: {}
- name: rx_gain
  id: variable_config
  parameters:
    config_file: conf
    option: gain
    section: rx
    type: int
    value: '35'
    writeback: None
  states: {}
- name: rx_samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rx_samp_rate
  id: variable_config
  parameters:
    comment: |-
      Dividing SDR clock rate
      by this should result in
      an even integer for best
      decimation
    config_file: conf
    option: sample_rate
    section: rx
    type: real
    value: 2e6
    writeback: None
  states: {}
- name: rx_symb_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: rx_beacon
    type: int
    value: '50000'
    writeback: None
  states: {}
- name: rx_target_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: target_frequency
    section: rx
    type: real
    value: 436.5e6
    writeback: None
  states: {}
- name: rx_tune_frequency
  id: variable
  parameters:
    value: rx_target_frequency - f_offset
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sample_decimation_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: uniclogs_ieee802_15_4_variant_decoder_0
  id: uniclogs_ieee802_15_4_variant_decoder
  parameters:
    preamble: preamble
    preamble_thrsh: '5'
    sync_thrsh: '1'
    sync_word: SFD0
  states: {}
- name: blocks_freqshift_cc_1
  id: blocks_freqshift_cc
  parameters:
    comment: |-
      Doppler Correction and LO offset
      Shifting 436.5 IQ to 436
    freq: '-500k'
    sample_rate: rx_samp_rate
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    comment: Recovered APRS
  states: {}
- name: digital_gfsk_demod_0_0_1
  id: digital_gfsk_demod
  parameters:
    comment: |-
      Sensitivity from 
      textbook (whch ???)

      old gain is 0.175
      (2 * rx_samp_per_sym) / np.pi
    freq_error: '0.0'
    gain_mu: '0.175'
    log: 'True'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: '4'
    sensitivity: rx_samp_rate / (2*np.pi*rx_symb_rate)
    verbose: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0_0_1
  id: low_pass_filter
  parameters:
    comment: |-
      Also does some
      decimation
    cutoff_freq: rx_symb_rate*1.5
    decim: sample_decimation_rate
    gain: '1'
    samp_rate: rx_samp_rate
    type: fir_filter_ccf
    width: rx_symb_rate*0.75
    win: window.WIN_HAMMING
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: rx_tune_frequency
    comment: From the Ettus B200mini
    dev_addr: '"serial="+device_serial'
    gain0: rx_gain
    samp_rate: rx_samp_rate
    show_lo_controls: 'True'
    sync: pc_clock
    type: fc32
  states: {}
- name: uniclogs_frame_decoder_0
  id: uniclogs_frame_decoder
  parameters:
    decoder_object: uniclogs_ieee802_15_4_variant_decoder_0
    itype: byte
    vlen: '1'
  states: {}

connections:
- [blocks_freqshift_cc_1, '0', low_pass_filter_0_0_1, '0']
- [digital_gfsk_demod_0_0_1, '0', uniclogs_frame_decoder_0, '0']
- [low_pass_filter_0_0_1, '0', digital_gfsk_demod_0_0_1, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_1, '0']
- [uniclogs_frame_decoder_0, out, blocks_message_debug_0_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
