options:
  parameters:
    generate_options: qt_gui
    id: test_doppler_math
    output_language: python
  states: {}

blocks:
- name: dlc
  id: variable
  parameters:
    value: 1265e6
  states: {}
- name: dop
  id: variable
  parameters:
    value: dlc
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 10e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: dlc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_2_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: dop-dlc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: dop-dlc
    sample_rate: samp_rate
  states: {state: bypassed}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: dop
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: dop
  states: {state: disabled}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 0.0.0.0
    gpredict_port: '7358'
    verbose: 'True'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    nconnections: '2'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_divide_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_freqshift_cc_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_2, '0', blocks_divide_xx_0, '1']
- [analog_sig_source_x_2_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_divide_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_throttle_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_throttle_0_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_throttle_0_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_throttle_0_0_0, '0', qtgui_freq_sink_x_1, '1']
- [gpredict_doppler_0, freq, analog_sig_source_x_0, cmd]
- [gpredict_doppler_0, freq, blocks_msgpair_to_var_0, inpair]
- [gpredict_doppler_0, freq, gpredict_MsgPairToVar_0, inpair]

metadata:
  file_format: 1
