options:
  parameters:
    generate_options: qt_gui
    id: test_doppler_messaging
    output_language: python
  states: {}

blocks:
- name: downlink_center
  id: variable
  parameters:
    value: 436.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    alias: ktesting
  states: {}
- name: blocks_pdu_set_0
  id: blocks_pdu_set
  parameters:
    k: pmt.intern("note")
    v: pmt.intern("doppler shift")
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nfreeqin = 0\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, downlink=0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='GPredict Doppler reducer',   # will show up in GRC\n            in_sig=None,\n            out_sig=None\n        )\n        self.downlink = downlink\n        self.message_port_register_in(pmt.intern('gpredict_freq'))\n        self.message_port_register_out(pmt.intern('freq'))\n        self.set_msg_handler(pmt.intern('gpredict_freq'), self.handle_msg)\n\n    def handle_msg(self, msg):\n        global freeqin\n        if pmt.is_pair(msg):\n            freeqin = pmt.to_python(pmt.cdr(msg)) - self.downlink\n            #self.message_port_pub(pmt.intern('freq'),pmt.from_double(freeqin))\n            self.message_port_pub(pmt.intern('freq'),pmt.cons(pmt.intern('freq'),pmt.from_double(freeqin)))\n            #print('published: \"%i\"'%freeqin)\n\n"
    downlink: downlink_center
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: '7356'
    verbose: 'True'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0_0, '0']
- [blocks_pdu_set_0, pdus, blocks_message_debug_0, print_pdu]
- [blocks_throttle_0_0, '0', qtgui_freq_sink_x_1, '0']
- [epy_block_0, freq, analog_sig_source_x_0, freq]
- [epy_block_0, freq, blocks_message_debug_0, print]
- [gpredict_doppler_0, freq, epy_block_0, gpredict_freq]

metadata:
  file_format: 1
