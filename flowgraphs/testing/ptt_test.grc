options:
  parameters:
    author: chin
    generate_options: qt_gui
    id: ptt_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: unmute
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Mute
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_2
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(9,[ord(x) for x in '!l_tx_on\n']))
    period: int(5e3)
  states: {state: disabled}
- name: blocks_msg_meta_to_pair_0
  id: blocks_msg_meta_to_pair
  parameters:
    keyin: key in
    keyout: key out
  states: {state: disabled}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: not bool(unmute)
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: localhost
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: unmute
  states: {}
- name: gpredict_rotor_0
  id: gpredict_rotor
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: '4533'
    minEl: '20.0'
    verbose: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_1, '0']
- [blocks_message_strobe_0, strobe, blocks_message_debug_0, print_pdu]
- [blocks_message_strobe_0, strobe, blocks_socket_pdu_0, pdus]
- [blocks_mute_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_throttle_1, '0', blocks_mute_xx_0, '0']
- [gpredict_rotor_0, state, blocks_message_debug_2, print]
- [gpredict_rotor_0, state, gpredict_MsgPairToVar_0, inpair]

metadata:
  file_format: 1
