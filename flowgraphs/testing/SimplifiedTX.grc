options:
  parameters:
    author: GlennL & KennyM
    generate_options: qt_gui
    id: hrftx
    output_language: python
    title: Simplified TX
  states: {}

blocks:
- name: EDL_strobe_command
  id: variable_config
  parameters:
    config_file: conf
    option: edl_command_number
    section: edl_commands
    type: string
    value: c4f53800003100000100000001e500017a7715fd13ff27df16880dbe3aca6e7ce2e1fa00a28426945342e12e6f4614ca
    writeback: None
  states: {}
- name: ppm
  id: variable_qtgui_range
  parameters:
    start: '-10'
    step: '.1'
    stop: '10'
    value: '-7.4'
  states: {}
- name: rf_samp_rate
  id: variable_config
  parameters:
    config_file: conf
    option: rf_samp_rate
    section: main
    type: real
    value: 1.92e6
    writeback: None
  states: {}
- name: samples_per_symbol
  id: variable_config
  parameters:
    config_file: conf
    option: samples_per_symbol
    section: main
    type: int
    value: '4'
    writeback: None
  states: {}
- name: tx_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: txband
    type: int
    value: '60000'
    writeback: None
  states: {}
- name: tx_center_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: center_frequency
    section: txband
    type: real
    value: 1265e6
    writeback: None
  states: {}
- name: tx_channel
  id: variable_config
  parameters:
    config_file: conf
    option: channel
    section: txband
    type: int
    value: '0'
    writeback: None
  states: {}
- name: tx_deviation
  id: variable_config
  parameters:
    config_file: conf
    option: deviation
    section: txband
    type: int
    value: '20000'
    writeback: None
  states: {}
- name: tx_occupied_bandwidth
  id: variable
  parameters:
    value: tx_bit_rate+2*tx_deviation
  states: {}
- name: tx_path
  id: variable_config
  parameters:
    config_file: conf
    option: path
    section: txband
    type: int
    value: '2'
    writeback: None
  states: {}
- name: blocks_message_debug_0_0_0_0_0_0_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0_0_0_0_0_0_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(bytes.fromhex(EDL_strobe_command)), list(bytes.fromhex(EDL_strobe_command))))
    period: strobe_delay
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: samples_per_symbol
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_0_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: conf
  id: parameter
  parameters:
    label: config file
    short_id: c
    type: str
    value: OreSat0.cfg
  states: {}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'True'
    length_tag_name: packet_len
    post_padding: 16*1024
    pre_padding: 16*1024
    type: complex
    window: firdes.window(window.WIN_HANN, 50, 0)
  states: {}
- name: digital_gfsk_mod_0_0_0
  id: digital_gfsk_mod
  parameters:
    bt: tx_bt
    samples_per_symbol: samples_per_symbol
    sensitivity: np.pi*(2*tx_deviation/tx_bit_rate)/samples_per_symbol
  states: {}
- name: digital_scrambler_bb_0_0_0
  id: digital_scrambler_bb
  parameters:
    comment: https://destevez.net/2016/05/scramblers-and-their-implementation-in-gnuradio/
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: edl_command_number
  id: parameter
  parameters:
    label: the command number, found in the edl_commands section of the config file, for repeat attempts of sending the same command
    short_id: e
    type: str
    value: default
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: tx_occupied_bandwidth * 1.2
    decim: '1'
    gain: '1'
    samp_rate: rf_samp_rate
    type: fir_filter_ccf
    width: tx_bit_rate
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    bw0: tx_center_frequency
    corr0: ppm
    freq0: tx_center_frequency
    gain0: '0'
    if_gain0: tx_gain
    sample_rate: rf_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pdu_pdu_lambda_0
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda x: np.packbits(np.unpackbits(x, bitorder=''little''))'
    metadict: Uniform Vector
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: int(tx_bit_rate * samples_per_symbol)
    fc: '0'
    fftsize: '1024'
    legend: 'False'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: rf_samp_rate
    fc: tx_center_frequency
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    legend: 'False'
    size: '13390'
    srate: int(tx_bit_rate * samples_per_symbol)
    tr_delay: '15'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: packet_len
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    legend: 'False'
    size: 13390*8
    srate: rf_samp_rate
    tr_delay: '15'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: packet_len
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: rational_resampler_xxx_2_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(tx_bit_rate * samples_per_symbol)
    interp: int(rf_samp_rate)
    taps: ''
    type: ccc
  states: {}
- name: satellites_hdlc_framer_0_0_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '16'
    preamble_bytes: '32'
  states: {}
- name: satellites_nrzi_encode_0_0_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: strobe_delay
  id: parameter
  parameters:
    label: the ms delay between sending EDL commands
    short_id: d
    type: intx
    value: '500'
  states: {}
- name: tx_bt
  id: parameter
  parameters:
    short_id: g
    type: eng_float
    value: '0.5'
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    short_id: t
    type: intx
    value: '15'
  states: {}
- name: txband
  id: parameter
  parameters:
    short_id: b
    type: str
    value: tx_l
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: byte
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: comp
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: byte
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: comp
  states: {}

connections:
- [blocks_message_strobe_0_0, strobe, blocks_message_debug_0_0_0_0_0_0_0_0_0_0_0, print]
- [blocks_message_strobe_0_0, strobe, pdu_pdu_lambda_0, pdu]
- [blocks_tagged_stream_multiply_length_0, '0', virtual_sink_1, '0']
- [blocks_unpacked_to_packed_xx_0_0_0, '0', digital_gfsk_mod_0_0_0, '0']
- [digital_burst_shaper_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_burst_shaper_xx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_burst_shaper_xx_0, '0', rational_resampler_xxx_2_0_0_0_0, '0']
- [digital_gfsk_mod_0_0_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [digital_scrambler_bb_0_0_0, '0', satellites_nrzi_encode_0_0_0, '0']
- [low_pass_filter_0_0_0, '0', osmosdr_sink_0, '0']
- [low_pass_filter_0_0_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [pdu_pdu_lambda_0, pdu, blocks_message_debug_0_0_0_0_0_0_0_0_0_0, print]
- [pdu_pdu_lambda_0, pdu, satellites_hdlc_framer_0_0_0, in]
- [pdu_pdu_to_tagged_stream_0_0_0, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_2_0_0_0_0, '0', low_pass_filter_0_0_0, '0']
- [satellites_hdlc_framer_0_0_0, out, blocks_message_debug_0_0_0_0_0_0_0_0_0, print]
- [satellites_hdlc_framer_0_0_0, out, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [satellites_nrzi_encode_0_0_0, '0', blocks_unpacked_to_packed_xx_0_0_0, '0']
- [virtual_source_0, '0', digital_scrambler_bb_0_0_0, '0']
- [virtual_source_1, '0', digital_burst_shaper_xx_0, '0']

metadata:
  file_format: 1
