options:
  parameters:
    catch_exceptions: 'False'
    comment: |-
      ~
      See:
      https://github.com/oresat/uniclogs-sdr/flowgraphs
    generate_options: qt_gui
    id: OreSat1_Simple
    output_language: python
    run_options: run
    title: UHF G3RUH & EDL Receiver / UHF -or- L-Band EDL Transmitter
  states: {}

blocks:
- name: beacon_filt_decimation
  id: variable
  parameters:
    value: '20'
  states: {}
- name: beacon_host
  id: variable_config
  parameters:
    config_file: conf
    option: telemetry_host
    section: main
    type: string
    value: localhost
    writeback: None
  states: {}
- name: device_serial
  id: variable_config
  parameters:
    config_file: conf
    option: '"device_serial"'
    section: main
    type: string
    value: ''
    writeback: None
  states: {}
- name: edl_filt_decimation
  id: variable
  parameters:
    value: '2'
  states: {}
- name: edl_host
  id: variable_config
  parameters:
    config_file: conf
    option: command_host
    section: main
    type: string
    value: localhost
    writeback: None
  states: {}
- name: f_offset
  id: variable
  parameters:
    comment: |-
      Pick out our RF
      carrier in the Rx
      bandwidth
    value: rx_samp_rate/4
  states: {}
- name: gpredict_rx_frequency
  id: variable
  parameters:
    value: rx_target_frequency
  states: {}
- name: gpredict_tx_frequency
  id: variable
  parameters:
    value: tx_center_frequency
  states: {}
- name: header_format
  id: variable
  parameters:
    value: digital.header_format_default(preamble, 0)
  states: {}
- name: morse_ident
  id: variable
  parameters:
    value: None
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '"0101010101010101010101010101010101010101010101010101010101010101"'
  states: {}
- name: rx_beacon_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: rx_beacon
    type: int
    value: '9600'
    writeback: None
  states: {}
- name: rx_edl_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: rx_edl
    type: int
    value: '96000'
    writeback: None
  states: {}
- name: rx_gain
  id: variable_config
  parameters:
    config_file: conf
    option: gain
    section: rx
    type: int
    value: '35'
    writeback: None
  states: {}
- name: rx_iq_data_filename
  id: variable_config
  parameters:
    config_file: conf
    option: iq_filename
    section: rx
    type: string
    value: delete_me.iq
    writeback: None
  states: {}
- name: rx_samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rx_samp_rate
  id: variable_config
  parameters:
    comment: |-
      Dividing SDR clock rate
      by this should result in
      an even integer for best
      decimation
    config_file: conf
    option: sample_rate
    section: rx
    type: real
    value: 2e6
    writeback: None
  states: {}
- name: rx_target_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: target_frequency
    section: rx
    type: real
    value: 436.5e6
    writeback: None
  states: {}
- name: rx_tune_frequency
  id: variable
  parameters:
    value: rx_target_frequency - f_offset
  states: {}
- name: sfd_phr
  id: variable
  parameters:
    value: '"01110010000010010100"'
  states: {}
- name: tx_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: txband
    type: int
    value: '60000'
    writeback: None
  states: {}
- name: tx_bt
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: tx_center_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: center_frequency
    section: txband
    type: real
    value: 1265e6
    writeback: None
  states: {}
- name: tx_lo_offset
  id: variable
  parameters:
    comment: |-
      Deviation * 4
      MSK m=0.5
    value: 2 * tx_bit_rate
  states: {}
- name: tx_samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: tx_samp_per_sym * tx_bit_rate
  states: {}
- name: analog_sig_source_x_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: CW test source
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: tx_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      Will generate empty file
      when not in use
    file: rx_iq_data_filename
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: file_sink
    type: byte
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    comment: Doppler Correction
    freq: gpredict_tx_frequency - tx_center_frequency
    sample_rate: tx_samp_rate
  states: {state: disabled}
- name: blocks_freqshift_cc_1
  id: blocks_freqshift_cc
  parameters:
    comment: |-
      Doppler Correction and
      LO offset
    freq: rx_tune_frequency - gpredict_rx_frequency
    sample_rate: rx_samp_rate
  states: {state: disabled}
- name: blocks_freqshift_cc_1_0
  id: blocks_freqshift_cc
  parameters:
    comment: |-
      Doppler Correction and
      LO offset
    freq: rx_tune_frequency - gpredict_rx_frequency
    sample_rate: rx_samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Recovered APRS
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    comment: Recovered EDL
  states: {state: disabled}
- name: blocks_message_debug_0_0_0_0_0_0_1_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '[''cw'', ''edl'', ''morse''].index(tx_selector)'
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {state: disabled}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    comment: |-
      Mutes IQ data (does not
      save to file) if filename is
      blank
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: int(rx_iq_data_filename != 'delete_me.iq')
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: tx_samp_per_sym
    lengthtagname: packet_len
    type: complex
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: ''
    target: morse_ident
  states: {state: disabled}
- name: conf
  id: parameter
  parameters:
    label: config file
    short_id: c
    type: str
    value: OreSat05.cfg
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '101010'
    type: byte
  states: {state: disabled}
- name: digital_correlate_access_code_tag_xx_0_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '101010'
    type: byte
  states: {state: disabled}
- name: digital_correlate_access_code_tag_xx_1
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: preamble
    tagname: packet_len
    threshold: ' 0'
    type: byte
  states: {}
- name: digital_gfsk_demod_0_0
  id: digital_gfsk_demod
  parameters:
    comment: |-
      Sensitivity from 
      textbook (whch ???)
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: rx_samp_per_sym
    sensitivity: 2 * rx_samp_per_sym / np.pi
  states: {state: disabled}
- name: digital_gfsk_demod_0_0_0
  id: digital_gfsk_demod
  parameters:
    comment: |-
      Sensitivity from 
      textbook (whch ???)
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: rx_samp_per_sym
    sensitivity: 2 * rx_samp_per_sym / np.pi
  states: {state: disabled}
- name: digital_gfsk_demod_0_0_1
  id: digital_gfsk_demod
  parameters:
    comment: |-
      Sensitivity from 
      textbook (whch ???)
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: rx_samp_per_sym
    sensitivity: (2 * rx_samp_per_sym) / np.pi
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: 'tx_bt '
    do_unpack: 'False'
    samples_per_symbol: tx_samp_per_sym
  states: {state: disabled}
- name: digital_packet_headerparser_b_0
  id: digital_packet_headerparser_b
  parameters: {}
  states: {state: disabled}
- name: iq_data
  id: blocks_file_source
  parameters:
    file: /home/ha/PSAS/uniclogs-sdr/flowgraphs/ESI-IQ_AT86_data/beacon_only.cf32
    length: '32095320'
    repeat: 'False'
    type: complex
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    comment: |-
      Also does some
      pre-decimation
    cutoff_freq: rx_beacon_bit_rate*1.5
    decim: beacon_filt_decimation
    gain: '1'
    samp_rate: rx_samp_rate
    type: fir_filter_ccf
    width: rx_beacon_bit_rate*0.75
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    comment: |-
      Also does some
      pre-decimation
    cutoff_freq: rx_edl_bit_rate*1.5
    decim: edl_filt_decimation
    gain: '1'
    samp_rate: rx_samp_rate
    type: fir_filter_ccf
    width: rx_edl_bit_rate*0.75
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0_1
  id: low_pass_filter
  parameters:
    comment: |-
      Also does some
      pre-decimation
    cutoff_freq: rx_beacon_bit_rate*1.5
    decim: beacon_filt_decimation
    gain: '1'
    samp_rate: rx_samp_rate
    type: fir_filter_ccf
    width: rx_beacon_bit_rate*0.75
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    comment: Received APRS beacon
    host: beacon_host
    mtu: '10000'
    port: '10015'
    type: UDP_CLIENT
  states: {state: disabled}
- name: network_socket_pdu_0_0_0_0
  id: network_socket_pdu
  parameters:
    comment: EDL uplink
    mtu: '10000'
    port: '10025'
    type: UDP_SERVER
  states: {state: disabled}
- name: network_socket_pdu_0_1
  id: network_socket_pdu
  parameters:
    comment: Received EDL response
    host: edl_host
    mtu: '10000'
    port: '10016'
    type: UDP_CLIENT
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: TX path here
  states: {}
- name: note_1
  id: note
  parameters:
    note: master clock needs to be a multiple of both TX and RX sample rates
  states: {}
- name: note_2
  id: note
  parameters:
    note: FIXME LO offset via command?
  states: {}
- name: note_3
  id: note
  parameters:
    note: Beacon path
  states: {}
- name: note_4
  id: note
  parameters:
    note: RX path here
  states: {}
- name: note_5
  id: note
  parameters:
    note: EDL path
  states: {}
- name: numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_pdu_lambda_0
  id: pdu_pdu_lambda
  parameters:
    comment: |-
      Converts morse_ident to pdu
      Is there a better way?
    fn: 'lambda x: pmt.intern(morse_ident)'
    metadict: Raw Message
  states: {state: disabled}
- name: pdu_pdu_lambda_1
  id: pdu_pdu_lambda
  parameters:
    comment: Reverse bit order
    fn: 'lambda x: np.packbits(np.unpackbits(x, bitorder=''little''))'
    metadict: Uniform Vector
  states: {state: disabled}
- name: pdu_pdu_set_0
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("note")
    v: pmt.intern("beacon")
  states: {state: disabled}
- name: pdu_pdu_set_1
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("note")
    v: pmt.intern("Received EDL")
  states: {state: disabled}
- name: pdu_pdu_set_2
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("note")
    v: pmt.intern("EDL to send")
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: ''
    type: byte
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: tx_samp_rate
    fc: tx_center_frequency
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '5000'
    srate: tx_samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: rx_samp_rate
    type: float
    update_time: '0.01'
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Can this just do the
      low pass filtering in
      one step?
    decim: int(rx_samp_rate)//beacon_filt_decimation
    interp: rx_beacon_bit_rate * rx_samp_per_sym
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(rx_samp_rate)//edl_filt_decimation
    interp: rx_edl_bit_rate * rx_samp_per_sym
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_1
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Can this just do the
      low pass filtering in
      one step?
    decim: int(rx_samp_rate)//beacon_filt_decimation
    interp: rx_beacon_bit_rate * rx_samp_per_sym
    taps: ''
    type: ccc
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    short_id: t
    type: intx
    value: '1'
  states: {}
- name: tx_selector
  id: parameter
  parameters:
    comment: one of  'cw', 'edl', 'morse'
    label: startup state of TX Selector (cw, edl, morse)
    short_id: s
    type: str
    value: edl
  states: {}
- name: txband
  id: parameter
  parameters:
    short_id: b
    type: str
    value: tx_l
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: uhd.tune_request(tx_center_frequency, tx_lo_offset)
    dev_addr: '"serial="+device_serial'
    gain0: tx_gain
    len_tag_name: packet_len
    samp_rate: tx_samp_rate
    show_lo_controls: 'True'
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: rx_tune_frequency
    comment: From the Ettus B200mini
    dev_addr: '"serial="+device_serial'
    gain0: rx_gain
    samp_rate: rx_samp_rate
    show_lo_controls: 'True'
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: '10080'
  states: {}

connections:
- [analog_sig_source_x_0_1_0, '0', blocks_selector_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_tag_debug_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_freqshift_cc_1, '0', blocks_selector_1, '0']
- [blocks_freqshift_cc_1, '0', low_pass_filter_0_0, '0']
- [blocks_freqshift_cc_1, '0', low_pass_filter_0_0_0, '0']
- [blocks_freqshift_cc_1_0, '0', low_pass_filter_0_0_1, '0']
- [blocks_selector_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_selector_1, '0', blocks_null_sink_1, '0']
- [blocks_selector_1, '1', blocks_file_sink_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', blocks_selector_0, '1']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_var_to_msg_0, msgout, pdu_pdu_lambda_0, pdu]
- [digital_correlate_access_code_tag_xx_0, '0', digital_correlate_access_code_tag_xx_0_0, '0']
- [digital_correlate_access_code_tag_xx_1, '0', blocks_file_sink_1, '0']
- [digital_correlate_access_code_tag_xx_1, '0', blocks_uchar_to_float_0, '0']
- [digital_correlate_access_code_tag_xx_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_gfsk_demod_0_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_gfsk_demod_0_0, '0', digital_packet_headerparser_b_0, '0']
- [digital_gfsk_demod_0_0_1, '0', digital_correlate_access_code_tag_xx_1, '0']
- [digital_gmsk_mod_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']
- [iq_data, '0', blocks_freqshift_cc_1_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [low_pass_filter_0_0_1, '0', rational_resampler_xxx_0_0_1, '0']
- [network_socket_pdu_0_0_0_0, pdus, pdu_pdu_lambda_1, pdu]
- [network_socket_pdu_0_0_0_0, pdus, pdu_pdu_set_2, pdus]
- [pdu_pdu_set_0, pdus, blocks_message_debug_0, print]
- [pdu_pdu_set_1, pdus, blocks_message_debug_0_0, print]
- [pdu_pdu_set_2, pdus, blocks_message_debug_0_0_0_0_0_0_1_0, print]
- [rational_resampler_xxx_0_0, '0', digital_gfsk_demod_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', digital_gfsk_demod_0_0_0, '0']
- [rational_resampler_xxx_0_0_1, '0', digital_gfsk_demod_0_0_1, '0']
- [uhd_usrp_sink_0_0, async_msgs, blocks_message_debug_1, print]
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
