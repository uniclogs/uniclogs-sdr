options:
  parameters:
    catch_exceptions: 'False'
    comment: |-
      ~
      See:
      https://github.com/oresat/uniclogs-sdr/flowgraphs
    generate_options: no_gui
    id: OreSat1_Simple
    output_language: python
    run_options: run
    title: UHF G3RUH & EDL Receiver / UHF -or- L-Band EDL Transmitter
  states: {}

blocks:
- name: SFD0
  id: variable
  parameters:
    value: '[0x90, 0x4e]'
  states: {}
- name: SFD1
  id: variable
  parameters:
    value: '[0x6F, 0x4e]'
  states: {}
- name: crc_16
  id: variable
  parameters:
    value: '0x1021'
  states: {}
- name: crc_32
  id: variable
  parameters:
    value: '0x04C11DB7'
  states: {}
- name: f_offset
  id: variable
  parameters:
    comment: |-
      Pick out our RF
      carrier in the Rx
      bandwidth
    value: rx_samp_rate/4
  states: {}
- name: filter_decimation
  id: variable
  parameters:
    value: int(rx_samp_rate/(rx_samp_per_sym*rx_symb_rate))
  states: {state: disabled}
- name: ieee_encoder
  id: uniclogs_variable_ieee802_15_4_encoder
  parameters:
    frame_len: '240'
    preamble: '0x55'
    preamble_len: '8'
    sync_word: SFD0
  states: {}
- name: nrnsc_polynomials
  id: variable
  parameters:
    value: '[0xF, 0x7]'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[0b0101_0101]*8'
  states: {}
- name: rsc_polynomials
  id: variable
  parameters:
    comment: Check second polynomial, its not right
    value: '[0x1, 0xE]'
  states: {}
- name: rx_gain
  id: variable_config
  parameters:
    config_file: conf
    option: gain
    section: rx
    type: int
    value: '35'
    writeback: None
  states: {}
- name: rx_samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rx_samp_rate
  id: variable_config
  parameters:
    comment: |-
      Dividing SDR clock rate
      by this should result in
      an even integer for best
      decimation
    config_file: conf
    option: sample_rate
    section: rx
    type: real
    value: 2e6
    writeback: None
  states: {}
- name: rx_symb_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: rx_beacon
    type: int
    value: '50000'
    writeback: None
  states: {}
- name: rx_target_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: target_frequency
    section: rx
    type: real
    value: 436.5e6
    writeback: None
  states: {}
- name: rx_tune_frequency
  id: variable
  parameters:
    value: rx_target_frequency - f_offset
  states: {}
- name: tx_center_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: center_frequency
    section: txband
    type: real
    value: 1265*10**6
    writeback: None
  states: {}
- name: tx_lo_offset
  id: variable
  parameters:
    comment: |-
      Deviation * 4
      MSK m=0.5
    value: 2 * tx_symb_rate
  states: {}
- name: tx_samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: tx_samp_per_sym * tx_symb_rate
  states: {}
- name: tx_symb_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: txband
    type: int
    value: '50000'
    writeback: None
  states: {}
- name: RX_PATH
  id: note
  parameters:
    note: RX path here
  states: {}
- name: TX_PATH
  id: note
  parameters:
    note: TX path here
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: rx_samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: (30, 40, 50)
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_gfsk_demod_0_0_1
  id: digital_gfsk_demod
  parameters:
    comment: |-
      Sensitivity from 
      textbook (whch ???)

      old gain is 0.175
      (2 * rx_samp_per_sym) / np.pi
    freq_error: '0.0'
    gain_mu: '0.175'
    log: 'True'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: '4'
    sensitivity: rx_samp_rate / (2*np.pi*rx_symb_rate)
    verbose: 'True'
  states: {state: disabled}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: '2'
  states: {state: disabled}
- name: freq_shift
  id: blocks_freqshift_cc
  parameters:
    freq: '-500e3'
    sample_rate: rx_samp_rate
  states: {state: disabled}
- name: iq_data
  id: blocks_file_source
  parameters:
    comment: |-
      32095320 samples @ 2 Msps (16.0 s), sps=40
      len= 240   PHR=0000000011110000
    length: '32095320'
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: low_pass_filter_0_0_1
  id: low_pass_filter
  parameters:
    comment: |-
      Also does some
      decimation
    cutoff_freq: rx_symb_rate*1.5
    decim: filter_decimation
    gain: '1'
    samp_rate: rx_samp_rate
    type: fir_filter_ccf
    width: rx_symb_rate*0.75
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: 127.0.0.1
    mode: '1'
    port: '10016'
    type: byte
  states: {state: disabled}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '10025'
    server: 'False'
    type: byte
  states: {state: disabled}
- name: numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    short_id: t
    type: intx
    value: '1'
  states: {}
- name: txband
  id: parameter
  parameters:
    short_id: b
    type: str
    value: tx_l
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: uhd.tune_request(tx_center_frequency, tx_lo_offset)
    dev_addr: '"serial="+device_serial'
    gain0: tx_gain
    len_tag_name: packet_len
    samp_rate: tx_samp_rate
    show_lo_controls: 'True'
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_1
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: rx_tune_frequency
    comment: From the Ettus B200mini
    dev_addr: '"serial="+device_serial'
    gain0: rx_gain
    samp_rate: rx_samp_rate
    show_lo_controls: 'True'
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uniclogs_frame_decoder_0
  id: uniclogs_frame_decoder
  parameters:
    decoder_object: None
    itype: byte
    vlen: '1'
  states: {state: disabled}
- name: uniclogs_frame_encoder_0
  id: uniclogs_frame_encoder
  parameters:
    encoder_object: ieee_encoder
  states: {}

connections:
- [blocks_throttle2_0, '0', low_pass_filter_0_0_1, '0']
- [blocks_vector_source_x_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_crc_append_0, out, uniclogs_frame_encoder_0, pdu]
- [digital_gfsk_demod_0_0_1, '0', uniclogs_frame_decoder_0, '0']
- [digital_gmsk_mod_0, '0', uhd_usrp_sink_0_0, '0']
- [freq_shift, '0', low_pass_filter_0_0_1, '0']
- [iq_data, '0', blocks_throttle2_0, '0']
- [low_pass_filter_0_0_1, '0', digital_gfsk_demod_0_0_1, '0']
- [network_tcp_source_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [pdu_pdu_to_stream_x_0, '0', network_tcp_sink_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', digital_gmsk_mod_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, digital_crc_append_0, in]
- [uhd_usrp_source_0_1, '0', freq_shift, '0']
- [uniclogs_frame_decoder_0, out, blocks_message_debug_0, print]
- [uniclogs_frame_decoder_0, out, pdu_pdu_to_stream_x_0, pdus]
- [uniclogs_frame_encoder_0, pdu, blocks_message_debug_0_0, log]
- [uniclogs_frame_encoder_0, pdu, pdu_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
