options:
  parameters:
    catch_exceptions: 'False'
    comment: |-
      ~
      See:
      https://github.com/oresat/uniclogs-sdr/flowgraphs
    generate_options: no_gui
    id: OreSat1_Simple
    output_language: python
    run_options: run
    title: UHF G3RUH & EDL Receiver / UHF -or- L-Band EDL Transmitter
  states: {}

blocks:
- name: crc_16
  id: variable
  parameters:
    value: '0x1021'
  states: {}
- name: crc_32
  id: variable
  parameters:
    value: '0x04C11DB7'
  states: {}
- name: f_offset
  id: variable
  parameters:
    comment: |-
      Pick out our RF
      carrier in the Rx
      bandwidth
    value: rx_samp_rate/4
  states: {}
- name: filter_decimation
  id: variable
  parameters:
    value: int(rx_samp_rate/(rx_samp_per_sym*rx_bit_rate))
  states: {}
- name: gpredict_tx_frequency
  id: variable
  parameters:
    value: tx_center_frequency
  states: {}
- name: ieee_var
  id: variable_ieee802_15_4_variable_decoder
  parameters:
    length_field_bytes: '2'
    preamble: '[0b0101_0101]*8'
    preamble_thrsh: '4'
    sync_thrsh: '1'
    sync_word: '[0x90, 0x4e]'
  states: {}
- name: ieee_var_encode
  id: variable_ieee802_15_4_variable_encoder
  parameters:
    length_field_bytes: '2'
    preamble: '0x55'
    preamble_len: '8'
    sync_word: '[0x90, 0x4e]'
  states: {}
- name: nrnsc_polynomials
  id: variable
  parameters:
    value: '[0x1E, 0xE]'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[0b0101_0101]*8'
  states: {}
- name: rsc_polynomials
  id: variable
  parameters:
    comment: Check second polynomial, its not right
    value: '[0x1, 0xE]'
  states: {}
- name: rx_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: rx_beacon
    type: int
    value: '50000'
    writeback: None
  states: {}
- name: rx_gain
  id: variable_config
  parameters:
    config_file: conf
    option: gain
    section: rx
    type: int
    value: '35'
    writeback: None
  states: {}
- name: rx_samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rx_samp_rate
  id: variable_config
  parameters:
    comment: |-
      Dividing SDR clock rate
      by this should result in
      an even integer for best
      decimation
    config_file: conf
    option: sample_rate
    section: rx
    type: real
    value: 2e6
    writeback: None
  states: {}
- name: rx_target_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: target_frequency
    section: rx
    type: real
    value: 436.5e6
    writeback: None
  states: {}
- name: rx_tune_frequency
  id: variable
  parameters:
    value: rx_target_frequency - f_offset
  states: {}
- name: tx_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: txband
    type: int
    value: '50000'
    writeback: None
  states: {}
- name: tx_bt
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: tx_center_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: center_frequency
    section: txband
    type: real
    value: 1265e6
    writeback: None
  states: {}
- name: tx_lo_offset
  id: variable
  parameters:
    comment: |-
      Deviation * 4
      MSK m=0.5
    value: 2 * tx_bit_rate
  states: {}
- name: tx_samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: tx_samp_per_sym * tx_bit_rate
  states: {}
- name: RX_PATH
  id: note
  parameters:
    note: RX path here
  states: {}
- name: TX_PATH
  id: note
  parameters:
    note: TX path here
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: ./output/raw_bytes_3
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: ./output/frames_3
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: rx_samp_rate
    type: complex
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    poly: crc_32
    swap_endianness: 'True'
  states: {}
- name: digital_gfsk_demod_0_0_1
  id: digital_gfsk_demod
  parameters:
    comment: |-
      Sensitivity from 
      textbook (whch ???)

      old gain is 0.175
      (2 * rx_samp_per_sym) / np.pi
    freq_error: '0.0'
    gain_mu: '0.175'
    log: 'True'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: '4'
    sensitivity: rx_samp_rate / (2*np.pi*rx_bit_rate)
    verbose: 'True'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: tx_bt
    do_unpack: 'False'
    samples_per_symbol: tx_samp_per_sym
  states: {}
- name: frame_decoder
  id: satnogs_frame_decoder
  parameters:
    decoder_object: ieee_var
    itype: byte
    vlen: '1'
  states: {}
- name: freq_shift
  id: blocks_freqshift_cc
  parameters:
    freq: 500e3
    sample_rate: rx_samp_rate
  states: {state: bypassed}
- name: iq_data
  id: blocks_file_source
  parameters:
    comment: |-
      32095320 samples @ 2 Msps (16.0 s), sps=40
      len= 240   PHR=0000000011110000
    file: /home/ha/Projects/PSAS/uniclogs-sdr/flowgraphs/raw_iq/beacon_only.cf32
    length: '32095320'
    repeat: 'False'
    type: complex
  states: {}
- name: low_pass_filter_0_0_1
  id: low_pass_filter
  parameters:
    comment: |-
      Also does some
      decimation
    cutoff_freq: rx_bit_rate*1.5
    decim: filter_decimation
    gain: '1'
    samp_rate: rx_samp_rate
    type: fir_filter_ccf
    width: rx_bit_rate*0.75
    win: window.WIN_HAMMING
  states: {}
- name: nrnsc_decoder
  id: satellites_viterbi_decoder
  parameters:
    constraint: '4'
    polynomials: '[0x1E, 0xE]'
  states: {}
- name: numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_pdu_lambda_0
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda x: np.unpackbits(x)'
    metadict: Uniform Vector
  states: {}
- name: pdu_pdu_lambda_0_0
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda x: np.packbits(x)'
    metadict: Uniform Vector
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: rx_samp_rate
    fc: 402e6
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: satellites_convolutional_encoder_0
  id: satellites_convolutional_encoder
  parameters:
    comment: FEC is generated with PHR and PSDU only
    constraint: '7'
    polynomials: nrnsc_polynomials
  states: {}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'False'
    max_length: '300'
  states: {state: disabled}
- name: satnogs_frame_encoder_0
  id: satnogs_frame_encoder
  parameters:
    comment: Need to just append preamble and SFD here
    encoder_object: ieee_var_encode
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    short_id: t
    type: intx
    value: '1'
  states: {}
- name: txband
  id: parameter
  parameters:
    short_id: b
    type: str
    value: tx_l
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: uhd.tune_request(tx_center_frequency, tx_lo_offset)
    dev_addr: '"serial="+device_serial'
    gain0: tx_gain
    len_tag_name: packet_len
    samp_rate: tx_samp_rate
    show_lo_controls: 'True'
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0_1
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: rx_tune_frequency
    comment: From the Ettus B200mini
    dev_addr: '"serial="+device_serial'
    gain0: rx_gain
    samp_rate: rx_samp_rate
    show_lo_controls: 'True'
    sync: pc_clock
    type: fc32
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0_0, '0']
- [blocks_throttle2_0, '0', low_pass_filter_0_0_1, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_crc_append_0, out, satellites_convolutional_encoder_0, in]
- [digital_crc_check_0, ok, blocks_message_debug_1_0_0, print]
- [digital_gfsk_demod_0_0_1, '0', blocks_repack_bits_bb_0, '0']
- [digital_gfsk_demod_0_0_1, '0', frame_decoder, '0']
- [digital_gmsk_mod_0, '0', uhd_usrp_sink_0_0, '0']
- [frame_decoder, out, pdu_pdu_lambda_0, pdu]
- [frame_decoder, out, pdu_pdu_to_stream_x_0, pdus]
- [freq_shift, '0', blocks_throttle2_0, '0']
- [iq_data, '0', freq_shift, '0']
- [low_pass_filter_0_0_1, '0', digital_gfsk_demod_0_0_1, '0']
- [nrnsc_decoder, out, pdu_pdu_lambda_0_0, pdu]
- [pdu_pdu_lambda_0, pdu, nrnsc_decoder, in]
- [pdu_pdu_lambda_0_0, pdu, digital_crc_check_0, in]
- [pdu_pdu_to_stream_x_0, '0', blocks_file_sink_0_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', digital_gmsk_mod_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, digital_crc_append_0, in]
- [satellites_convolutional_encoder_0, out, satnogs_frame_encoder_0, pdu]
- [satnogs_frame_encoder_0, pdu, pdu_pdu_to_tagged_stream_0, pdus]
- [uhd_usrp_sink_0_0, async_msgs, blocks_message_debug_1, print]
- [uhd_usrp_source_0_1, '0', freq_shift, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
