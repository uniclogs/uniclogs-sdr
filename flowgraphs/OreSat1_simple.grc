options:
  parameters:
    catch_exceptions: 'False'
    comment: |-
      ~
      See:
      https://github.com/oresat/uniclogs-sdr/flowgraphs
    generate_options: qt_gui
    id: OreSat1_Simple
    output_language: python
    run_options: run
    title: UHF G3RUH & EDL Receiver / UHF -or- L-Band EDL Transmitter
  states: {}

blocks:
- name: f_offset
  id: variable
  parameters:
    comment: |-
      Pick out our RF
      carrier in the Rx
      bandwidth
    value: rx_samp_rate/4
  states: {}
- name: filter_decimation
  id: variable
  parameters:
    value: int(rx_samp_rate/(rx_samp_per_sym*rx_bit_rate))
  states: {}
- name: gpredict_tx_frequency
  id: variable
  parameters:
    value: tx_center_frequency
  states: {}
- name: ieee_var
  id: variable_ieee802_15_4_variable_decoder
  parameters:
    length_field_bytes: '2'
    preamble: '[0b0101_0101]*8'
    preamble_thrsh: '4'
    sync_thrsh: '1'
    sync_word: '[0x90, 0x4e]'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[0b0101_0101]*8'
  states: {}
- name: rx_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: rx_beacon
    type: int
    value: '50000'
    writeback: None
  states: {}
- name: rx_gain
  id: variable_config
  parameters:
    config_file: conf
    option: gain
    section: rx
    type: int
    value: '35'
    writeback: None
  states: {}
- name: rx_iq_data_filename
  id: variable_config
  parameters:
    config_file: conf
    option: iq_filename
    section: rx
    type: string
    value: delete_me.iq
    writeback: None
  states: {}
- name: rx_samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rx_samp_rate
  id: variable_config
  parameters:
    comment: |-
      Dividing SDR clock rate
      by this should result in
      an even integer for best
      decimation
    config_file: conf
    option: sample_rate
    section: rx
    type: real
    value: 2e6
    writeback: None
  states: {}
- name: rx_target_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: target_frequency
    section: rx
    type: real
    value: 436.5e6
    writeback: None
  states: {}
- name: rx_tune_frequency
  id: variable
  parameters:
    value: rx_target_frequency - f_offset
  states: {}
- name: rx_tune_frequency_0
  id: variable
  parameters:
    value: rx_target_frequency - f_offset
  states: {}
- name: tx_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: txband
    type: int
    value: '60000'
    writeback: None
  states: {}
- name: tx_bt
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: tx_center_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: center_frequency
    section: txband
    type: real
    value: 1265e6
    writeback: None
  states: {}
- name: tx_lo_offset
  id: variable
  parameters:
    comment: |-
      Deviation * 4
      MSK m=0.5
    value: 2 * tx_bit_rate
  states: {}
- name: tx_samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: tx_samp_per_sym * tx_bit_rate
  states: {}
- name: variable_scrambler_0
  id: variable_scrambler
  parameters:
    mask: '0xa9'
    msb: 'True'
    order: '7'
    seed: '0xff'
    self_sync: 'False'
  states: {state: disabled}
- name: RX_PATH
  id: note
  parameters:
    note: RX path here
  states: {}
- name: TX_PATH
  id: note
  parameters:
    note: TX path here
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (2*np.pi*rx_bit_rate)/(rx_samp_per_sym * rx_bit_rate)
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: file_sink
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: ./output/raw_bytes
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: raw_binary
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: ./output/file_sink
    type: byte
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    comment: Doppler Correction
    freq: gpredict_tx_frequency - tx_center_frequency
    sample_rate: tx_samp_rate
  states: {state: disabled}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: tx_samp_per_sym
    lengthtagname: packet_len
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: rx_samp_rate
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_gfsk_demod_0_0_1
  id: digital_gfsk_demod
  parameters:
    comment: |-
      Sensitivity from 
      textbook (whch ???)

      old gain is 0.175
      (2 * rx_samp_per_sym) / np.pi
    freq_error: '0.0'
    gain_mu: '0.175'
    log: 'True'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: '4'
    sensitivity: rx_samp_rate / (2*np.pi*rx_bit_rate)
    verbose: 'True'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: 'tx_bt '
    do_unpack: 'False'
    samples_per_symbol: tx_samp_per_sym
  states: {state: disabled}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: 1/math.sqrt(2)
    loop_bw: 2*math.pi/(rx_samp_rate/filter_decimation)
    max_dev: '0.1'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: rx_samp_per_sym
    ted_gain: '1.0'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: ff
  states: {state: disabled}
- name: fec_async_encoder_0_1
  id: fec_async_encoder
  parameters:
    comment: descrambler
    encoder: variable_scrambler_0
    mtu: frame_size+4
    packed: 'True'
    rev_pack: 'False'
    rev_unpack: 'False'
  states: {state: disabled}
- name: frame_decoder
  id: satnogs_frame_decoder
  parameters:
    decoder_object: ieee_var
    itype: byte
    vlen: '1'
  states: {}
- name: freq_shift
  id: blocks_freqshift_cc
  parameters:
    freq: 500e3
    sample_rate: rx_samp_rate
  states: {state: bypassed}
- name: iq_data
  id: blocks_file_source
  parameters:
    comment: |-
      32095320 samples @ 2 Msps (16.0 s), sps=40
      len= 240   PHR=0000000011110000
    file: /home/ha/Projects/PSAS/uniclogs-sdr/flowgraphs/raw_iq/raw_iq_beacons_nopa.cf32
    length: '32095320'
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: low_pass_filter_0_0_1
  id: low_pass_filter
  parameters:
    comment: |-
      Also does some
      decimation
    cutoff_freq: rx_bit_rate*1.5
    decim: filter_decimation
    gain: '1'
    samp_rate: rx_samp_rate
    type: fir_filter_ccf
    width: rx_bit_rate*0.75
    win: window.WIN_HAMMING
  states: {}
- name: numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: pdu_pdu_to_stream_x_0_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: tx_samp_rate
    fc: tx_center_frequency
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '5000'
    srate: tx_samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: rx_samp_rate
    fc: 402e6
    fftsize: '1024'
    type: complex
  states: {}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'False'
    max_length: '300'
  states: {state: disabled}
- name: satnogs_crc_async_2
  id: satnogs_crc_async
  parameters:
    check: 'True'
    custom_crc: satnogs.crc.crc16(0x1021, 0xFFFF, 0xFFFF, True, True)
    nbo: 'True'
    type: CRC32_C
  states: {state: disabled}
- name: tx_gain
  id: parameter
  parameters:
    short_id: t
    type: intx
    value: '1'
  states: {}
- name: txband
  id: parameter
  parameters:
    short_id: b
    type: str
    value: tx_l
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: uhd.tune_request(tx_center_frequency, tx_lo_offset)
    dev_addr: '"serial="+device_serial'
    gain0: tx_gain
    len_tag_name: packet_len
    samp_rate: tx_samp_rate
    show_lo_controls: 'True'
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: rx_tune_frequency
    gain0: '0'
    samp_rate: rx_samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 402e6
    gain0: rx_gain
    samp_rate: rx_samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_tag_debug_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_throttle2_0, '0', low_pass_filter_0_0_1, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_binary_slicer_fb_0, '0', frame_decoder, '0']
- [digital_gfsk_demod_0_0_1, '0', blocks_file_sink_0_0_0, '0']
- [digital_gfsk_demod_0_0_1, '0', blocks_repack_bits_bb_0, '0']
- [digital_gfsk_demod_0_0_1, '0', frame_decoder, '0']
- [digital_gmsk_mod_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_binary_slicer_fb_0, '0']
- [fec_async_encoder_0_1, out, satnogs_crc_async_2, in]
- [frame_decoder, out, blocks_message_debug_1_0_0, print]
- [frame_decoder, out, pdu_pdu_to_stream_x_0, pdus]
- [freq_shift, '0', blocks_throttle2_0, '0']
- [iq_data, '0', freq_shift, '0']
- [low_pass_filter_0_0_1, '0', analog_quadrature_demod_cf_0_0, '0']
- [low_pass_filter_0_0_1, '0', digital_gfsk_demod_0_0_1, '0']
- [pdu_pdu_to_stream_x_0, '0', blocks_file_sink_0_1, '0']
- [pdu_pdu_to_stream_x_0_0, '0', blocks_file_sink_0, '0']
- [satellites_hdlc_deframer_0, out, pdu_pdu_to_stream_x_0_0, pdus]
- [uhd_usrp_sink_0_0, async_msgs, blocks_message_debug_1, print]
- [uhd_usrp_source_0_0, '0', freq_shift, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
