options:
  parameters:
    catch_exceptions: 'False'
    comment: |-
      ~
      See:
      https://github.com/oresat/uniclogs-sdr/flowgraphs
    generate_options: no_gui
    id: OreSat1_Simple
    output_language: python
    run_options: run
    title: UHF G3RUH & EDL Receiver / UHF -or- L-Band EDL Transmitter
  states: {}

blocks:
- name: f_offset
  id: variable
  parameters:
    comment: |-
      Pick out our RF
      carrier in the Rx
      bandwidth
    value: rx_samp_rate/4
  states: {}
- name: filter_decimation
  id: variable
  parameters:
    value: int(rx_samp_rate/(rx_samp_per_sym*rx_bit_rate))
  states: {}
- name: gpredict_tx_frequency
  id: variable
  parameters:
    value: tx_center_frequency
  states: {}
- name: ieee_frame
  id: variable_ieee802_15_4_variant_decoder
  parameters:
    frame_len: '240'
    preamble: '[85, 85, 85, 85, 85, 85, 85]'
    preamble_thrsh: '8'
    sync_thrsh: '8'
    sync_word: '[114, 9]'
  states: {}
- name: ieee_var
  id: variable_ieee802_15_4_variable_decoder
  parameters:
    length_field_bytes: '1'
    preamble: '[85, 85, 85, 85, 85, 85, 85]'
    preamble_thrsh: '8'
    sync_thrsh: '8'
    sync_word: '[114, 9]'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[0x55, 0x55, 0x55, 0x55, 0x55]'
  states: {}
- name: rx_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: rx_beacon
    type: int
    value: '50000'
    writeback: None
  states: {}
- name: rx_gain
  id: variable_config
  parameters:
    config_file: conf
    option: gain
    section: rx
    type: int
    value: '35'
    writeback: None
  states: {}
- name: rx_iq_data_filename
  id: variable_config
  parameters:
    config_file: conf
    option: iq_filename
    section: rx
    type: string
    value: delete_me.iq
    writeback: None
  states: {}
- name: rx_samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rx_samp_rate
  id: variable_config
  parameters:
    comment: |-
      Dividing SDR clock rate
      by this should result in
      an even integer for best
      decimation
    config_file: conf
    option: sample_rate
    section: rx
    type: real
    value: 2e6
    writeback: None
  states: {}
- name: rx_target_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: target_frequency
    section: rx
    type: real
    value: 436.5e6
    writeback: None
  states: {}
- name: rx_tune_frequency
  id: variable
  parameters:
    value: rx_target_frequency - f_offset
  states: {}
- name: rx_tune_frequency_0
  id: variable
  parameters:
    value: rx_target_frequency - f_offset
  states: {}
- name: tx_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: txband
    type: int
    value: '60000'
    writeback: None
  states: {}
- name: tx_bt
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: tx_center_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: center_frequency
    section: txband
    type: real
    value: 1265e6
    writeback: None
  states: {}
- name: tx_lo_offset
  id: variable
  parameters:
    comment: |-
      Deviation * 4
      MSK m=0.5
    value: 2 * tx_bit_rate
  states: {}
- name: tx_samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: tx_samp_per_sym * tx_bit_rate
  states: {}
- name: RX_PATH
  id: note
  parameters:
    note: RX path here
  states: {}
- name: TX_PATH
  id: note
  parameters:
    note: TX path here
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: file_sink
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: raw_bytes
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: raw_binary
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: file_sink
    type: byte
  states: {state: disabled}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    comment: Doppler Correction
    freq: gpredict_tx_frequency - tx_center_frequency
    sample_rate: tx_samp_rate
  states: {state: disabled}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: tx_samp_per_sym
    lengthtagname: packet_len
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: rx_samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: digital_gfsk_demod_0_0_1
  id: digital_gfsk_demod
  parameters:
    comment: |-
      Sensitivity from 
      textbook (whch ???)

      old gain is 0.175
      (2 * rx_samp_per_sym) / np.pi
    freq_error: '0.0'
    gain_mu: '0.175'
    log: 'True'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: rx_samp_per_sym
    sensitivity: rx_samp_rate / (2*np.pi*filter_decimation)
    verbose: 'True'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: 'tx_bt '
    do_unpack: 'False'
    samples_per_symbol: tx_samp_per_sym
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: '1.0'
  states: {state: disabled}
- name: frame_decoder
  id: satnogs_frame_decoder
  parameters:
    decoder_object: ieee_var
    itype: byte
    vlen: '1'
  states: {state: disabled}
- name: iq_data
  id: blocks_file_source
  parameters:
    comment: |-
      32095320 samples @ 2 Msps (16.0 s), sps=40
      len= 240   PHR=0000000011110000
    file: beacon_only.cf32
    length: '32095320'
    repeat: 'False'
    type: complex
  states: {}
- name: low_pass_filter_0_0_1
  id: low_pass_filter
  parameters:
    comment: |-
      Also does some
      decimation
    cutoff_freq: rx_bit_rate*1.5
    decim: filter_decimation
    gain: '1'
    samp_rate: rx_samp_rate
    type: fir_filter_ccf
    width: rx_bit_rate*0.75
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: localhost
    mtu: '10000'
    port: '10015'
    type: UDP_SERVER
  states: {state: disabled}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {state: disabled}
- name: numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_pdu_set_0
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("note")
    v: pmt.intern("packet")
  states: {state: disabled}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_stream_x_0_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: tx_samp_rate
    fc: tx_center_frequency
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '5000'
    srate: tx_samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: rx_samp_rate
    type: float
    update_time: '0.01'
  states: {state: disabled}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'False'
    max_length: '300'
  states: {state: disabled}
- name: tx_gain
  id: parameter
  parameters:
    short_id: t
    type: intx
    value: '1'
  states: {}
- name: txband
  id: parameter
  parameters:
    short_id: b
    type: str
    value: tx_l
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: uhd.tune_request(tx_center_frequency, tx_lo_offset)
    dev_addr: '"serial="+device_serial'
    gain0: tx_gain
    len_tag_name: packet_len
    samp_rate: tx_samp_rate
    show_lo_controls: 'True'
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: rx_tune_frequency
    gain0: '0'
    samp_rate: rx_samp_rate
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [blocks_freqshift_cc_0, '0', blocks_tag_debug_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_throttle2_0, '0', low_pass_filter_0_0_1, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [digital_gfsk_demod_0_0_1, '0', blocks_file_sink_0_0_0, '0']
- [digital_gfsk_demod_0_0_1, '0', blocks_repack_bits_bb_0, '0']
- [digital_gfsk_demod_0_0_1, '0', frame_decoder, '0']
- [digital_gmsk_mod_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']
- [epy_block_0, '0', network_socket_pdu_0, pdus]
- [epy_block_0, '0', pdu_pdu_set_0, pdus]
- [frame_decoder, out, blocks_message_debug_1_0_0, print]
- [frame_decoder, out, pdu_pdu_to_stream_x_0, pdus]
- [iq_data, '0', blocks_throttle2_0, '0']
- [low_pass_filter_0_0_1, '0', digital_gfsk_demod_0_0_1, '0']
- [pdu_pdu_set_0, pdus, blocks_message_debug_1_0, print]
- [pdu_pdu_to_stream_x_0, '0', blocks_file_sink_0_1, '0']
- [pdu_pdu_to_stream_x_0, '0', satellites_hdlc_deframer_0, '0']
- [pdu_pdu_to_stream_x_0_0, '0', blocks_file_sink_0, '0']
- [satellites_hdlc_deframer_0, out, blocks_message_debug_1_0_0, print]
- [satellites_hdlc_deframer_0, out, pdu_pdu_to_stream_x_0_0, pdus]
- [uhd_usrp_sink_0_0, async_msgs, blocks_message_debug_1, print]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
