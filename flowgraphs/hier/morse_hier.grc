options:
  parameters:
    generate_options: hb
    id: morse_hier
    output_language: python
    title: Morse Code Generator
  states: {}

blocks:
- name: morse_samp_rate
  id: variable
  parameters:
    comment: Samples per Second
    value: 50e3
  states: {}
- name: morse_sps
  id: variable
  parameters:
    comment: Samples per Symbol
    value: int(60 * morse_samp_rate / morse_dpw / morse_wpm)
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: morse_samp_rate/morse_sps
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: '300'
  states: {state: disabled}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_repeat_0_0_0
  id: blocks_repeat
  parameters:
    interp: int(rf_samp_rate/morse_samp_rate)
    type: complex
  states: {}
- name: blocks_repeat_0_1
  id: blocks_repeat
  parameters:
    interp: morse_sps
    type: byte
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Morse code vector source
      """

      #  epy_block_0.py
      #  revised 09/10/2019 - finish code table
      #  revised 09/11/2019 - test for bad character
      #  revised 09/27/2019 - get input from a Message Edit block (code from Volker Schroer dl1ksv)

      import numpy as np
      from gnuradio import gr

      import pmt

      class mc_sync_block(gr.sync_block):
          """
          reads input from a message port
          generates a vector of Morse code bits
          """

          Morse = {
            # codes from https://www.itu.int/rec/R-REC-M.1677-1-200910-I/en
              "A": [1,0,1,1,1],
              "B": [1,1,1,0,1,0,1,0,1],
              "C": [1,1,1,0,1,0,1,1,1,0,1],
              "D": [1,1,1,0,1,0,1],
              "E": [1],
              "F": [1,0,1,0,1,1,1,0,1],
              "G": [1,1,1,0,1,1,1,0,1],
              "H": [1,0,1,0,1,0,1],
              "I": [1,0,1],
              "J": [1,0,1,1,1,0,1,1,1,0,1,1,1],
              "K": [1,1,1,0,1,0,1,1,1],
              "L": [1,0,1,1,1,0,1,0,1],
              "M": [1,1,1,0,1,1,1],
              "N": [1,1,1,0,1],
              "O": [1,1,1,0,1,1,1,0,1,1,1],
              "P": [1,0,1,1,1,0,1,1,1,0,1],
              "Q": [1,1,1,0,1,1,1,0,1,0,1,1,1],
              "R": [1,0,1,1,1,0,1],
              "S": [1,0,1,0,1],
              "T": [1,1,1],
              "U": [1,0,1,0,1,1,1],
              "V": [1,0,1,0,1,0,1,1,1],
              "W": [1,0,1,1,1,0,1,1,1],
              "X": [1,1,1,0,1,0,1,0,1,1,1],
              "Y": [1,1,1,0,1,0,1,1,1,0,1,1,1],
              "Z": [1,1,1,0,1,1,1,0,1,0,1],
              " ": [0],                   # space
              "ls": [0,0,0],              # letter space
              "ws": [0,0,0,0],            # word space
              "1": [1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,1,1],
              "2": [1,0,1,0,1,1,1,0,1,1,1,0,1,1,1],
              "3": [1,0,1,0,1,0,1,1,1,0,1,1,1],
              "4": [1,0,1,0,1,0,1,0,1,1,1],
              "5": [1,0,1,0,1,0,1,0,1],
              "6": [1,1,1,0,1,0,1,0,1,0,1],
              "7": [1,1,1,0,1,1,1,0,1,0,1,0,1],
              "8": [1,1,1,0,1,1,1,0,1,1,1,0,1,0,1],
              "9": [1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1],
              "0": [1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,1,1],
              ".": [1,0,1,1,1,0,1,0,1,1,1,0,1,0,1,1,1],          # period
              ",": [1,1,1,0,1,1,1,0,1,0,1,0,1,1,1,0,1,1,1],      # comma
              ":": [1,1,1,0,1,1,1,0,1,1,1,0,1,0,1,0,1],          # colon
              "?": [1,0,1,0,1,1,1,0,1,1,1,0,1,0,1],              # question
              "'": [1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1],      # apostrophe
              "-": [1,1,1,0,1,0,1,0,1,0,1,0,1,1,1],              # dash or minus
              "/": [1,1,1,0,1,0,1,0,1,1,1,0,1],                  # slash
              "(": [1,1,1,0,1,0,1,1,1,0,1,1,1,0,1],              # left parenthesis
              ")": [1,1,1,0,1,0,1,1,1,0,1,1,1,0,1,0,1,1,1],      # right parenthesis
              "\"": [1,0,1,1,1,0,1,0,1,0,1,1,1,0,1],             # quote
              "=": [1,1,1,0,1,0,1,0,1,0,1,1,1],                  # equals
              "+": [1,0,1,1,1,0,1,0,1,1,1,0,1],                  # plus
              "@": [1,0,1,1,1,0,1,1,1,0,1,0,1,1,1,0,1],          # at sign (@)
            # these[punctuation marks are not included in the ITU recommendation,
            # but a[e found in https://en.wikipedia.org/wiki/Morse_code
              "!": [1,1,1,0,1,0,1,1,1,0,1,0,1,1,1,0,1,1,1],      # exclamation point
              "&": [1,0,1,1,1,0,1,0,1,0,1],                      # ampersand (also prosign for 'WAIT')
              ";": [1,1,1,0,1,0,1,1,1,0,1,0,1,1,1,0,1],          # semicolon
              "_": [1,0,1,0,1,1,1,0,1,1,1,0,1,0,1,1,1],          # underscore
              "$": [1,0,1,0,1,0,1,1,1,0,1,0,1,0,1,1,1]           # dollar sign
                }

          def __init__(self, verbose=True):
              gr.sync_block.__init__(self,
                  name = "Morse code vector source",
                  in_sig = None,
                  out_sig = [np.byte])
              self.verbose = verbose
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("clear_input"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)
              self.data = []
              self.alphaIn = ""

          def handle_msg(self, msg):
              if self.alphaIn:
                  self.alphaIn += " "
              self.alphaIn += str(pmt.symbol_to_string(msg)).upper()
              if self.verbose:
                  print("Sending Morse: %s" % self.alphaIn)
          
          def try_to_flush(self, out):
              # Try to send as many items as we have in buffer
              len_write = min(len(self.data), len(out))
              out[:len_write] = self.data[:len_write]
              self.data = self.data[len_write:]
              return len_write
          
          def noblock(self, out):
              len_write = len(out)
              print("noblock(%i)" % len_write)
              #if len_write:
              #    out[:len_write] = [0] * len_write
              return len_write

          def work(self, input_items, output_items):
              _num_elem = 0
              out = output_items[0]
              if self.data:
                  return self.try_to_flush(out)

              if self.alphaIn:
                  for ch in self.alphaIn:
                      # replace bad characters with a "?"
                      if not ch in self.Morse:
                          ch = "?"
                      _dots = self.Morse.get(ch)
                      if self.verbose:
                          print(ch, _dots)  # debugging
                      self.data.extend(_dots)
                      self.data.extend(self.Morse.get("ls"))

                  # finish with word space
                  self.data.extend(self.Morse.get("ws"))

                  # clear the input and text box
                  self.alphaIn = ""
                  self.message_port_pub(pmt.intern("clear_input"), pmt.intern(""))

                  return self.try_to_flush(out)

              return 0
              #return self.noblock(out)
    verbose: verbose
  states: {}
- name: morse_dpw
  id: parameter
  parameters:
    comment: |-
      50 - PARIS standard
      60 - CODEX standard
    label: Dits Per Word
    type: intx
    value: '50'
  states: {}
- name: morse_wpm
  id: parameter
  parameters:
    label: Words Per Minute
    type: intx
    value: '13'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: msg_in
    type: message
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '16384'
    srate: morse_samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '1.5'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: morse_samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: rf_samp_rate
  id: parameter
  parameters:
    label: RF Sample Rate
    type: eng_float
    value: 1e6
  states: {}
- name: root_raised_cosine_filter_0_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '0.95'
    ntaps: '200'
    samp_rate: morse_samp_rate
    sym_rate: sym_rate
    type: fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_1
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '200'
    samp_rate: morse_samp_rate
    sym_rate: sym_rate
    type: fir_filter_fff
  states: {}
- name: verbose
  id: parameter
  parameters:
    label: Verbose
    type: intx
    value: 'True'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: morse_wrap
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: morse_wrap
  states: {}

connections:
- [blocks_float_to_complex_0_0, '0', blocks_repeat_0_0_0, '0']
- [blocks_float_to_complex_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_repeat_0_0_0, '0', pad_sink_0, '0']
- [blocks_repeat_0_1, '0', blocks_uchar_to_float_0_0, '0']
- [blocks_uchar_to_float_0_0, '0', virtual_sink_0, '0']
- [epy_block_0_0_0, '0', blocks_repeat_0_1, '0']
- [pad_source_0, out, epy_block_0_0_0, msg_in]
- [root_raised_cosine_filter_0_0_0, '0', blocks_float_to_complex_0_0, '0']
- [root_raised_cosine_filter_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [root_raised_cosine_filter_0_1, '0', root_raised_cosine_filter_0_0_0, '0']
- [virtual_source_0, '0', root_raised_cosine_filter_0_1, '0']

metadata:
  file_format: 1
