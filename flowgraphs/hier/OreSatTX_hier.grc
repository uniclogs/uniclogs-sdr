options:
  parameters:
    author: GlennL & KennyM
    category: '[OreSat]'
    generate_options: hb
    id: OreSatTX_hier
    output_language: python
    title: OreSat Transmit
  states: {}

blocks:
- name: occupied_bandwidth
  id: variable
  parameters:
    value: bit_rate + 2*deviation
  states: {}
- name: bit_rate
  id: parameter
  parameters:
    label: Bit Rate
    type: intx
    value: '60000'
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_0_0_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: bt
  id: parameter
  parameters:
    label: BT
    type: eng_float
    value: '.5'
  states: {}
- name: deviation
  id: parameter
  parameters:
    label: Deviation
    type: intx
    value: '20000'
  states: {}
- name: digital_burst_shaper_xx_0_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'True'
    length_tag_name: packet_len
    post_padding: 32*1024-16
    pre_padding: '16'
    type: complex
    window: firdes.window(window.WIN_HANN, 50, 0)
  states: {}
- name: digital_gfsk_mod_0_0_0_0
  id: digital_gfsk_mod
  parameters:
    bt: bt
    samples_per_symbol: sps
    sensitivity: np.pi * (2 * deviation / bit_rate) / sps
  states: {}
- name: digital_scrambler_bb_0_0_0_0
  id: digital_scrambler_bb
  parameters:
    comment: https://destevez.net/2016/05/scramblers-and-their-implementation-in-gnuradio/
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: low_pass_filter_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: occupied_bandwidth * 1.2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: bit_rate
    win: window.WIN_HAMMING
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: message
  states: {}
- name: pdu_pdu_lambda_0_0_0
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda x: np.packbits(np.unpackbits(x, bitorder=''little''))'
    metadict: Uniform Vector
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: rational_resampler_xxx_2_0_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(bit_rate * sps)
    interp: int(samp_rate)
    taps: ''
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: RF Sample Rate
    type: eng_float
    value: 1e6
  states: {}
- name: satellites_hdlc_framer_0_0_0_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '16'
    preamble_bytes: '32'
  states: {}
- name: satellites_nrzi_encode_0_0_0_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples/Symbol
    type: intx
    value: '4'
  states: {}
- name: virtual_sink_5_0
  id: virtual_sink
  parameters:
    stream_id: HDLC_Frame
  states: {}
- name: virtual_sink_6_0
  id: virtual_sink
  parameters:
    stream_id: EDL_GFSK
  states: {}
- name: virtual_source_5_0
  id: virtual_source
  parameters:
    stream_id: HDLC_Frame
  states: {}
- name: virtual_source_6_0
  id: virtual_source
  parameters:
    stream_id: EDL_GFSK
  states: {}

connections:
- [blocks_tagged_stream_multiply_length_0_0, '0', digital_burst_shaper_xx_0_0, '0']
- [blocks_unpacked_to_packed_xx_0_0_0_0, '0', digital_gfsk_mod_0_0_0_0, '0']
- [digital_burst_shaper_xx_0_0, '0', rational_resampler_xxx_2_0_0_0_0_0, '0']
- [digital_gfsk_mod_0_0_0_0, '0', virtual_sink_6_0, '0']
- [digital_scrambler_bb_0_0_0_0, '0', satellites_nrzi_encode_0_0_0_0, '0']
- [low_pass_filter_0_0_0_0, '0', pad_sink_0, '0']
- [pad_source_0, out, pdu_pdu_lambda_0_0_0, pdu]
- [pdu_pdu_lambda_0_0_0, pdu, satellites_hdlc_framer_0_0_0_0, in]
- [pdu_pdu_to_tagged_stream_0_0_0_0, '0', virtual_sink_5_0, '0']
- [rational_resampler_xxx_2_0_0_0_0_0, '0', low_pass_filter_0_0_0_0, '0']
- [satellites_hdlc_framer_0_0_0_0, out, pdu_pdu_to_tagged_stream_0_0_0_0, pdus]
- [satellites_nrzi_encode_0_0_0_0, '0', blocks_unpacked_to_packed_xx_0_0_0_0, '0']
- [virtual_source_5_0, '0', digital_scrambler_bb_0_0_0_0, '0']
- [virtual_source_6_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']

metadata:
  file_format: 1
