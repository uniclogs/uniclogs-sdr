options:
  parameters:
    author: GlennL & KennyM
    category: '[OreSat]'
    generate_options: hb
    id: OreSatRX_hier
    output_language: python
    title: OreSat Receive
  states: {}

blocks:
- name: bit_rate
  id: parameter
  parameters:
    label: Bit Rate
    type: intx
    value: '9600'
  states: {}
- name: digital_descrambler_bb_0_0
  id: digital_descrambler_bb
  parameters:
    comment: https://destevez.net/2016/05/scramblers-and-their-implementation-in-gnuradio/
    len: '16'
    mask: '0x0021'
    seed: '0x0000'
  states: {}
- name: digital_gfsk_demod_0_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: sps
    sensitivity: 2 * sps / np.pi
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: bit_rate*1.5
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: bit_rate*0.75
    win: window.WIN_HAMMING
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pdu_pdu_lambda_0_3_0
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda x: x if (len(x) >= len(starts_with)/2 and all(x[:int(len(starts_with)/2)] == list(bytes.fromhex(starts_with)))) else x[:0]'
    metadict: Uniform Vector
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate)
    interp: bit_rate * sps
    taps: ''
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: RF Sample Rate
    type: eng_float
    value: 1e6
  states: {}
- name: satellites_hdlc_deframer_0_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '300'
  states: {}
- name: satellites_nrzi_decode_0_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: satellites_pdu_length_filter_0_0_0
  id: satellites_pdu_length_filter
  parameters:
    max: '-1'
    min: '1'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples/Symbol
    type: intx
    value: '4'
  states: {}
- name: starts_with
  id: parameter
  parameters:
    label: Starts With
    type: str
    value: a6a082868a406096946ea682a8
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: demodulated
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: deframed
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: demodulated
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: deframed
  states: {}

connections:
- [digital_descrambler_bb_0_0, '0', satellites_hdlc_deframer_0_0, '0']
- [digital_gfsk_demod_0_0, '0', virtual_sink_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_0, '0']
- [pad_source_0, '0', low_pass_filter_0_0, '0']
- [pdu_pdu_lambda_0_3_0, pdu, satellites_pdu_length_filter_0_0_0, in]
- [rational_resampler_xxx_0_0, '0', digital_gfsk_demod_0_0, '0']
- [satellites_hdlc_deframer_0_0, out, virtual_sink_1, '0']
- [satellites_nrzi_decode_0_0, '0', digital_descrambler_bb_0_0, '0']
- [satellites_pdu_length_filter_0_0_0, out, pad_sink_0, in]
- [virtual_source_0, '0', satellites_nrzi_decode_0_0, '0']
- [virtual_source_1, '0', pdu_pdu_lambda_0_3_0, pdu]

metadata:
  file_format: 1
